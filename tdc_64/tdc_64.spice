* tdc_64
* Schematic generated by Substrate

.subckt tdc_64
+ vdd
+ vss
+ a
+ b
+ reset_b
+ dout[0]
+ dout[1]
+ dout[2]
+ dout[3]
+ dout[4]
+ dout[5]
+ dout[6]
+ dout[7]
+ dout[8]
+ dout[9]
+ dout[10]
+ dout[11]
+ dout[12]
+ dout[13]
+ dout[14]
+ dout[15]
+ dout[16]
+ dout[17]
+ dout[18]
+ dout[19]
+ dout[20]
+ dout[21]
+ dout[22]
+ dout[23]
+ dout[24]
+ dout[25]
+ dout[26]
+ dout[27]
+ dout[28]
+ dout[29]
+ dout[30]
+ dout[31]
+ dout[32]
+ dout[33]
+ dout[34]
+ dout[35]
+ dout[36]
+ dout[37]
+ dout[38]
+ dout[39]
+ dout[40]
+ dout[41]
+ dout[42]
+ dout[43]
+ dout[44]
+ dout[45]
+ dout[46]
+ dout[47]
+ dout[48]
+ dout[49]
+ dout[50]
+ dout[51]
+ dout[52]
+ dout[53]
+ dout[54]
+ dout[55]
+ dout[56]
+ dout[57]
+ dout[58]
+ dout[59]
+ dout[60]
+ dout[61]
+ dout[62]
+ dout[63]
+ dout[64]
+ dout[65]
+ dout[66]
+ dout[67]
+ dout[68]
+ dout[69]
+ dout[70]
+ dout[71]
+ dout[72]
+ dout[73]
+ dout[74]
+ dout[75]
+ dout[76]
+ dout[77]
+ dout[78]
+ dout[79]
+ dout[80]
+ dout[81]
+ dout[82]
+ dout[83]
+ dout[84]
+ dout[85]
+ dout[86]
+ dout[87]
+ dout[88]
+ dout[89]
+ dout[90]
+ dout[91]
+ dout[92]
+ dout[93]
+ dout[94]
+ dout[95]
+ dout[96]
+ dout[97]
+ dout[98]
+ dout[99]
+ dout[100]
+ dout[101]
+ dout[102]
+ dout[103]
+ dout[104]
+ dout[105]
+ dout[106]
+ dout[107]
+ dout[108]
+ dout[109]
+ dout[110]
+ dout[111]
+ dout[112]
+ dout[113]
+ dout[114]
+ dout[115]
+ dout[116]
+ dout[117]
+ dout[118]
+ dout[119]
+ dout[120]
+ dout[121]
+ dout[122]
+ dout[123]
+ dout[124]
+ dout[125]
+ dout[126]
+ dout[127]
+ dout[128]
+ dout[129]
+ dout[130]
+ dout[131]
+ dout[132]
+ dout[133]
+ dout[134]
+ dout[135]
+ dout[136]
+ dout[137]
+ dout[138]
+ dout[139]
+ dout[140]
+ dout[141]
+ dout[142]
+ dout[143]
+ dout[144]
+ dout[145]
+ dout[146]
+ dout[147]
+ dout[148]
+ dout[149]
+ dout[150]
+ dout[151]
+ dout[152]
+ dout[153]
+ dout[154]
+ dout[155]
+ dout[156]
+ dout[157]
+ dout[158]
+ dout[159]
+ dout[160]
+ dout[161]
+ dout[162]
+ dout[163]
+ dout[164]
+ dout[165]
+ dout[166]
+ dout[167]
+ dout[168]
+ dout[169]
+ dout[170]
+ dout[171]
+ dout[172]
+ dout[173]
+ dout[174]
+ dout[175]
+ dout[176]
+ dout[177]
+ dout[178]
+ dout[179]
+ dout[180]
+ dout[181]
+ dout[182]
+ dout[183]
+ dout[184]
+ dout[185]
+ dout[186]
+ dout[187]
+ dout[188]
+ dout[189]
+ dout[190]
+ dout[191]
+ dout[192]
+ dout[193]
+ dout[194]
+ dout[195]
+ dout[196]
+ dout[197]
+ dout[198]
+ dout[199]
+ dout[200]
+ dout[201]
+ dout[202]
+ dout[203]
+ dout[204]
+ dout[205]
+ dout[206]
+ dout[207]
+ dout[208]
+ dout[209]
+ dout[210]
+ dout[211]
+ dout[212]
+ dout[213]
+ dout[214]
+ dout[215]
+ dout[216]
+ dout[217]
+ dout[218]
+ dout[219]
+ dout[220]
+ dout[221]
+ dout[222]
+ dout[223]
+ dout[224]
+ dout[225]
+ dout[226]
+ dout[227]
+ dout[228]
+ dout[229]
+ dout[230]
+ dout[231]
+ dout[232]
+ dout[233]
+ dout[234]
+ dout[235]
+ dout[236]
+ dout[237]
+ dout[238]
+ dout[239]
+ dout[240]
+ dout[241]
+ dout[242]
+ dout[243]
+ dout[244]
+ dout[245]
+ dout[246]
+ dout[247]
+ dout[248]
+ dout[249]
+ dout[250]
+ dout[251]

Xs1buf_0_0
+ vdd
+ vss
+ a
+ int1[0]
+ inv
Xs1buf_0_1
+ vdd
+ vss
+ int1[0]
+ stage1[0]
+ inv
Xs1buf_1_0
+ vdd
+ vss
+ stage1[0]
+ int1[1]
+ inv
Xs1buf_1_1
+ vdd
+ vss
+ int1[1]
+ stage1[1]
+ inv
Xs1buf_2_0
+ vdd
+ vss
+ stage1[1]
+ int1[2]
+ inv
Xs1buf_2_1
+ vdd
+ vss
+ int1[2]
+ stage1[2]
+ inv
Xs1buf_3_0
+ vdd
+ vss
+ stage1[2]
+ int1[3]
+ inv
Xs1buf_3_1
+ vdd
+ vss
+ int1[3]
+ stage1[3]
+ inv
Xs1buf_4_0
+ vdd
+ vss
+ stage1[3]
+ int1[4]
+ inv
Xs1buf_4_1
+ vdd
+ vss
+ int1[4]
+ stage1[4]
+ inv
Xs1buf_5_0
+ vdd
+ vss
+ stage1[4]
+ int1[5]
+ inv
Xs1buf_5_1
+ vdd
+ vss
+ int1[5]
+ stage1[5]
+ inv
Xs1buf_6_0
+ vdd
+ vss
+ stage1[5]
+ int1[6]
+ inv
Xs1buf_6_1
+ vdd
+ vss
+ int1[6]
+ stage1[6]
+ inv
Xs1buf_7_0
+ vdd
+ vss
+ stage1[6]
+ int1[7]
+ inv
Xs1buf_7_1
+ vdd
+ vss
+ int1[7]
+ stage1[7]
+ inv
Xs1buf_8_0
+ vdd
+ vss
+ stage1[7]
+ int1[8]
+ inv
Xs1buf_8_1
+ vdd
+ vss
+ int1[8]
+ stage1[8]
+ inv
Xs1buf_9_0
+ vdd
+ vss
+ stage1[8]
+ int1[9]
+ inv
Xs1buf_9_1
+ vdd
+ vss
+ int1[9]
+ stage1[9]
+ inv
Xs1buf_10_0
+ vdd
+ vss
+ stage1[9]
+ int1[10]
+ inv
Xs1buf_10_1
+ vdd
+ vss
+ int1[10]
+ stage1[10]
+ inv
Xs1buf_11_0
+ vdd
+ vss
+ stage1[10]
+ int1[11]
+ inv
Xs1buf_11_1
+ vdd
+ vss
+ int1[11]
+ stage1[11]
+ inv
Xs1buf_12_0
+ vdd
+ vss
+ stage1[11]
+ int1[12]
+ inv
Xs1buf_12_1
+ vdd
+ vss
+ int1[12]
+ stage1[12]
+ inv
Xs1buf_13_0
+ vdd
+ vss
+ stage1[12]
+ int1[13]
+ inv
Xs1buf_13_1
+ vdd
+ vss
+ int1[13]
+ stage1[13]
+ inv
Xs1buf_14_0
+ vdd
+ vss
+ stage1[13]
+ int1[14]
+ inv
Xs1buf_14_1
+ vdd
+ vss
+ int1[14]
+ stage1[14]
+ inv
Xs1buf_15_0
+ vdd
+ vss
+ stage1[14]
+ int1[15]
+ inv
Xs1buf_15_1
+ vdd
+ vss
+ int1[15]
+ stage1[15]
+ inv
Xs1buf_16_0
+ vdd
+ vss
+ stage1[15]
+ int1[16]
+ inv
Xs1buf_16_1
+ vdd
+ vss
+ int1[16]
+ stage1[16]
+ inv
Xs1buf_17_0
+ vdd
+ vss
+ stage1[16]
+ int1[17]
+ inv
Xs1buf_17_1
+ vdd
+ vss
+ int1[17]
+ stage1[17]
+ inv
Xs1buf_18_0
+ vdd
+ vss
+ stage1[17]
+ int1[18]
+ inv
Xs1buf_18_1
+ vdd
+ vss
+ int1[18]
+ stage1[18]
+ inv
Xs1buf_19_0
+ vdd
+ vss
+ stage1[18]
+ int1[19]
+ inv
Xs1buf_19_1
+ vdd
+ vss
+ int1[19]
+ stage1[19]
+ inv
Xs1buf_20_0
+ vdd
+ vss
+ stage1[19]
+ int1[20]
+ inv
Xs1buf_20_1
+ vdd
+ vss
+ int1[20]
+ stage1[20]
+ inv
Xs1buf_21_0
+ vdd
+ vss
+ stage1[20]
+ int1[21]
+ inv
Xs1buf_21_1
+ vdd
+ vss
+ int1[21]
+ stage1[21]
+ inv
Xs1buf_22_0
+ vdd
+ vss
+ stage1[21]
+ int1[22]
+ inv
Xs1buf_22_1
+ vdd
+ vss
+ int1[22]
+ stage1[22]
+ inv
Xs1buf_23_0
+ vdd
+ vss
+ stage1[22]
+ int1[23]
+ inv
Xs1buf_23_1
+ vdd
+ vss
+ int1[23]
+ stage1[23]
+ inv
Xs1buf_24_0
+ vdd
+ vss
+ stage1[23]
+ int1[24]
+ inv
Xs1buf_24_1
+ vdd
+ vss
+ int1[24]
+ stage1[24]
+ inv
Xs1buf_25_0
+ vdd
+ vss
+ stage1[24]
+ int1[25]
+ inv
Xs1buf_25_1
+ vdd
+ vss
+ int1[25]
+ stage1[25]
+ inv
Xs1buf_26_0
+ vdd
+ vss
+ stage1[25]
+ int1[26]
+ inv
Xs1buf_26_1
+ vdd
+ vss
+ int1[26]
+ stage1[26]
+ inv
Xs1buf_27_0
+ vdd
+ vss
+ stage1[26]
+ int1[27]
+ inv
Xs1buf_27_1
+ vdd
+ vss
+ int1[27]
+ stage1[27]
+ inv
Xs1buf_28_0
+ vdd
+ vss
+ stage1[27]
+ int1[28]
+ inv
Xs1buf_28_1
+ vdd
+ vss
+ int1[28]
+ stage1[28]
+ inv
Xs1buf_29_0
+ vdd
+ vss
+ stage1[28]
+ int1[29]
+ inv
Xs1buf_29_1
+ vdd
+ vss
+ int1[29]
+ stage1[29]
+ inv
Xs1buf_30_0
+ vdd
+ vss
+ stage1[29]
+ int1[30]
+ inv
Xs1buf_30_1
+ vdd
+ vss
+ int1[30]
+ stage1[30]
+ inv
Xs1buf_31_0
+ vdd
+ vss
+ stage1[30]
+ int1[31]
+ inv
Xs1buf_31_1
+ vdd
+ vss
+ int1[31]
+ stage1[31]
+ inv
Xs1buf_32_0
+ vdd
+ vss
+ stage1[31]
+ int1[32]
+ inv
Xs1buf_32_1
+ vdd
+ vss
+ int1[32]
+ stage1[32]
+ inv
Xs1buf_33_0
+ vdd
+ vss
+ stage1[32]
+ int1[33]
+ inv
Xs1buf_33_1
+ vdd
+ vss
+ int1[33]
+ stage1[33]
+ inv
Xs1buf_34_0
+ vdd
+ vss
+ stage1[33]
+ int1[34]
+ inv
Xs1buf_34_1
+ vdd
+ vss
+ int1[34]
+ stage1[34]
+ inv
Xs1buf_35_0
+ vdd
+ vss
+ stage1[34]
+ int1[35]
+ inv
Xs1buf_35_1
+ vdd
+ vss
+ int1[35]
+ stage1[35]
+ inv
Xs1buf_36_0
+ vdd
+ vss
+ stage1[35]
+ int1[36]
+ inv
Xs1buf_36_1
+ vdd
+ vss
+ int1[36]
+ stage1[36]
+ inv
Xs1buf_37_0
+ vdd
+ vss
+ stage1[36]
+ int1[37]
+ inv
Xs1buf_37_1
+ vdd
+ vss
+ int1[37]
+ stage1[37]
+ inv
Xs1buf_38_0
+ vdd
+ vss
+ stage1[37]
+ int1[38]
+ inv
Xs1buf_38_1
+ vdd
+ vss
+ int1[38]
+ stage1[38]
+ inv
Xs1buf_39_0
+ vdd
+ vss
+ stage1[38]
+ int1[39]
+ inv
Xs1buf_39_1
+ vdd
+ vss
+ int1[39]
+ stage1[39]
+ inv
Xs1buf_40_0
+ vdd
+ vss
+ stage1[39]
+ int1[40]
+ inv
Xs1buf_40_1
+ vdd
+ vss
+ int1[40]
+ stage1[40]
+ inv
Xs1buf_41_0
+ vdd
+ vss
+ stage1[40]
+ int1[41]
+ inv
Xs1buf_41_1
+ vdd
+ vss
+ int1[41]
+ stage1[41]
+ inv
Xs1buf_42_0
+ vdd
+ vss
+ stage1[41]
+ int1[42]
+ inv
Xs1buf_42_1
+ vdd
+ vss
+ int1[42]
+ stage1[42]
+ inv
Xs1buf_43_0
+ vdd
+ vss
+ stage1[42]
+ int1[43]
+ inv
Xs1buf_43_1
+ vdd
+ vss
+ int1[43]
+ stage1[43]
+ inv
Xs1buf_44_0
+ vdd
+ vss
+ stage1[43]
+ int1[44]
+ inv
Xs1buf_44_1
+ vdd
+ vss
+ int1[44]
+ stage1[44]
+ inv
Xs1buf_45_0
+ vdd
+ vss
+ stage1[44]
+ int1[45]
+ inv
Xs1buf_45_1
+ vdd
+ vss
+ int1[45]
+ stage1[45]
+ inv
Xs1buf_46_0
+ vdd
+ vss
+ stage1[45]
+ int1[46]
+ inv
Xs1buf_46_1
+ vdd
+ vss
+ int1[46]
+ stage1[46]
+ inv
Xs1buf_47_0
+ vdd
+ vss
+ stage1[46]
+ int1[47]
+ inv
Xs1buf_47_1
+ vdd
+ vss
+ int1[47]
+ stage1[47]
+ inv
Xs1buf_48_0
+ vdd
+ vss
+ stage1[47]
+ int1[48]
+ inv
Xs1buf_48_1
+ vdd
+ vss
+ int1[48]
+ stage1[48]
+ inv
Xs1buf_49_0
+ vdd
+ vss
+ stage1[48]
+ int1[49]
+ inv
Xs1buf_49_1
+ vdd
+ vss
+ int1[49]
+ stage1[49]
+ inv
Xs1buf_50_0
+ vdd
+ vss
+ stage1[49]
+ int1[50]
+ inv
Xs1buf_50_1
+ vdd
+ vss
+ int1[50]
+ stage1[50]
+ inv
Xs1buf_51_0
+ vdd
+ vss
+ stage1[50]
+ int1[51]
+ inv
Xs1buf_51_1
+ vdd
+ vss
+ int1[51]
+ stage1[51]
+ inv
Xs1buf_52_0
+ vdd
+ vss
+ stage1[51]
+ int1[52]
+ inv
Xs1buf_52_1
+ vdd
+ vss
+ int1[52]
+ stage1[52]
+ inv
Xs1buf_53_0
+ vdd
+ vss
+ stage1[52]
+ int1[53]
+ inv
Xs1buf_53_1
+ vdd
+ vss
+ int1[53]
+ stage1[53]
+ inv
Xs1buf_54_0
+ vdd
+ vss
+ stage1[53]
+ int1[54]
+ inv
Xs1buf_54_1
+ vdd
+ vss
+ int1[54]
+ stage1[54]
+ inv
Xs1buf_55_0
+ vdd
+ vss
+ stage1[54]
+ int1[55]
+ inv
Xs1buf_55_1
+ vdd
+ vss
+ int1[55]
+ stage1[55]
+ inv
Xs1buf_56_0
+ vdd
+ vss
+ stage1[55]
+ int1[56]
+ inv
Xs1buf_56_1
+ vdd
+ vss
+ int1[56]
+ stage1[56]
+ inv
Xs1buf_57_0
+ vdd
+ vss
+ stage1[56]
+ int1[57]
+ inv
Xs1buf_57_1
+ vdd
+ vss
+ int1[57]
+ stage1[57]
+ inv
Xs1buf_58_0
+ vdd
+ vss
+ stage1[57]
+ int1[58]
+ inv
Xs1buf_58_1
+ vdd
+ vss
+ int1[58]
+ stage1[58]
+ inv
Xs1buf_59_0
+ vdd
+ vss
+ stage1[58]
+ int1[59]
+ inv
Xs1buf_59_1
+ vdd
+ vss
+ int1[59]
+ stage1[59]
+ inv
Xs1buf_60_0
+ vdd
+ vss
+ stage1[59]
+ int1[60]
+ inv
Xs1buf_60_1
+ vdd
+ vss
+ int1[60]
+ stage1[60]
+ inv
Xs1buf_61_0
+ vdd
+ vss
+ stage1[60]
+ int1[61]
+ inv
Xs1buf_61_1
+ vdd
+ vss
+ int1[61]
+ stage1[61]
+ inv
Xs1buf_62_0
+ vdd
+ vss
+ stage1[61]
+ int1[62]
+ inv
Xs1buf_62_1
+ vdd
+ vss
+ int1[62]
+ stage1[62]
+ inv
Xs1buf_63_0
+ vdd
+ vss
+ stage1[62]
+ int1[63]
+ inv
Xs1buf_63_1
+ vdd
+ vss
+ int1[63]
+ stage1[63]
+ inv
Xs2_0_0
+ vdd
+ vss
+ stage1[0]
+ stage2[0]
+ inv
Xs2_0_1
+ vdd
+ vss
+ stage1[0]
+ stage2[0]
+ inv
Xs3_0
+ vdd
+ vss
+ stage2[0]
+ stage3[0]
+ inv
Xs2_1_0
+ vdd
+ vss
+ stage1[0]
+ stage2[1]
+ inv
Xs2_1_1
+ vdd
+ vss
+ stage1[1]
+ stage2[1]
+ inv
Xs3_1
+ vdd
+ vss
+ stage2[1]
+ stage3[1]
+ inv
Xs2_2_0
+ vdd
+ vss
+ stage1[1]
+ stage2[2]
+ inv
Xs2_2_1
+ vdd
+ vss
+ stage1[1]
+ stage2[2]
+ inv
Xs3_2
+ vdd
+ vss
+ stage2[2]
+ stage3[2]
+ inv
Xs2_3_0
+ vdd
+ vss
+ stage1[1]
+ stage2[3]
+ inv
Xs2_3_1
+ vdd
+ vss
+ stage1[2]
+ stage2[3]
+ inv
Xs3_3
+ vdd
+ vss
+ stage2[3]
+ stage3[3]
+ inv
Xs2_4_0
+ vdd
+ vss
+ stage1[2]
+ stage2[4]
+ inv
Xs2_4_1
+ vdd
+ vss
+ stage1[2]
+ stage2[4]
+ inv
Xs3_4
+ vdd
+ vss
+ stage2[4]
+ stage3[4]
+ inv
Xs2_5_0
+ vdd
+ vss
+ stage1[2]
+ stage2[5]
+ inv
Xs2_5_1
+ vdd
+ vss
+ stage1[3]
+ stage2[5]
+ inv
Xs3_5
+ vdd
+ vss
+ stage2[5]
+ stage3[5]
+ inv
Xs2_6_0
+ vdd
+ vss
+ stage1[3]
+ stage2[6]
+ inv
Xs2_6_1
+ vdd
+ vss
+ stage1[3]
+ stage2[6]
+ inv
Xs3_6
+ vdd
+ vss
+ stage2[6]
+ stage3[6]
+ inv
Xs2_7_0
+ vdd
+ vss
+ stage1[3]
+ stage2[7]
+ inv
Xs2_7_1
+ vdd
+ vss
+ stage1[4]
+ stage2[7]
+ inv
Xs3_7
+ vdd
+ vss
+ stage2[7]
+ stage3[7]
+ inv
Xs2_8_0
+ vdd
+ vss
+ stage1[4]
+ stage2[8]
+ inv
Xs2_8_1
+ vdd
+ vss
+ stage1[4]
+ stage2[8]
+ inv
Xs3_8
+ vdd
+ vss
+ stage2[8]
+ stage3[8]
+ inv
Xs2_9_0
+ vdd
+ vss
+ stage1[4]
+ stage2[9]
+ inv
Xs2_9_1
+ vdd
+ vss
+ stage1[5]
+ stage2[9]
+ inv
Xs3_9
+ vdd
+ vss
+ stage2[9]
+ stage3[9]
+ inv
Xs2_10_0
+ vdd
+ vss
+ stage1[5]
+ stage2[10]
+ inv
Xs2_10_1
+ vdd
+ vss
+ stage1[5]
+ stage2[10]
+ inv
Xs3_10
+ vdd
+ vss
+ stage2[10]
+ stage3[10]
+ inv
Xs2_11_0
+ vdd
+ vss
+ stage1[5]
+ stage2[11]
+ inv
Xs2_11_1
+ vdd
+ vss
+ stage1[6]
+ stage2[11]
+ inv
Xs3_11
+ vdd
+ vss
+ stage2[11]
+ stage3[11]
+ inv
Xs2_12_0
+ vdd
+ vss
+ stage1[6]
+ stage2[12]
+ inv
Xs2_12_1
+ vdd
+ vss
+ stage1[6]
+ stage2[12]
+ inv
Xs3_12
+ vdd
+ vss
+ stage2[12]
+ stage3[12]
+ inv
Xs2_13_0
+ vdd
+ vss
+ stage1[6]
+ stage2[13]
+ inv
Xs2_13_1
+ vdd
+ vss
+ stage1[7]
+ stage2[13]
+ inv
Xs3_13
+ vdd
+ vss
+ stage2[13]
+ stage3[13]
+ inv
Xs2_14_0
+ vdd
+ vss
+ stage1[7]
+ stage2[14]
+ inv
Xs2_14_1
+ vdd
+ vss
+ stage1[7]
+ stage2[14]
+ inv
Xs3_14
+ vdd
+ vss
+ stage2[14]
+ stage3[14]
+ inv
Xs2_15_0
+ vdd
+ vss
+ stage1[7]
+ stage2[15]
+ inv
Xs2_15_1
+ vdd
+ vss
+ stage1[8]
+ stage2[15]
+ inv
Xs3_15
+ vdd
+ vss
+ stage2[15]
+ stage3[15]
+ inv
Xs2_16_0
+ vdd
+ vss
+ stage1[8]
+ stage2[16]
+ inv
Xs2_16_1
+ vdd
+ vss
+ stage1[8]
+ stage2[16]
+ inv
Xs3_16
+ vdd
+ vss
+ stage2[16]
+ stage3[16]
+ inv
Xs2_17_0
+ vdd
+ vss
+ stage1[8]
+ stage2[17]
+ inv
Xs2_17_1
+ vdd
+ vss
+ stage1[9]
+ stage2[17]
+ inv
Xs3_17
+ vdd
+ vss
+ stage2[17]
+ stage3[17]
+ inv
Xs2_18_0
+ vdd
+ vss
+ stage1[9]
+ stage2[18]
+ inv
Xs2_18_1
+ vdd
+ vss
+ stage1[9]
+ stage2[18]
+ inv
Xs3_18
+ vdd
+ vss
+ stage2[18]
+ stage3[18]
+ inv
Xs2_19_0
+ vdd
+ vss
+ stage1[9]
+ stage2[19]
+ inv
Xs2_19_1
+ vdd
+ vss
+ stage1[10]
+ stage2[19]
+ inv
Xs3_19
+ vdd
+ vss
+ stage2[19]
+ stage3[19]
+ inv
Xs2_20_0
+ vdd
+ vss
+ stage1[10]
+ stage2[20]
+ inv
Xs2_20_1
+ vdd
+ vss
+ stage1[10]
+ stage2[20]
+ inv
Xs3_20
+ vdd
+ vss
+ stage2[20]
+ stage3[20]
+ inv
Xs2_21_0
+ vdd
+ vss
+ stage1[10]
+ stage2[21]
+ inv
Xs2_21_1
+ vdd
+ vss
+ stage1[11]
+ stage2[21]
+ inv
Xs3_21
+ vdd
+ vss
+ stage2[21]
+ stage3[21]
+ inv
Xs2_22_0
+ vdd
+ vss
+ stage1[11]
+ stage2[22]
+ inv
Xs2_22_1
+ vdd
+ vss
+ stage1[11]
+ stage2[22]
+ inv
Xs3_22
+ vdd
+ vss
+ stage2[22]
+ stage3[22]
+ inv
Xs2_23_0
+ vdd
+ vss
+ stage1[11]
+ stage2[23]
+ inv
Xs2_23_1
+ vdd
+ vss
+ stage1[12]
+ stage2[23]
+ inv
Xs3_23
+ vdd
+ vss
+ stage2[23]
+ stage3[23]
+ inv
Xs2_24_0
+ vdd
+ vss
+ stage1[12]
+ stage2[24]
+ inv
Xs2_24_1
+ vdd
+ vss
+ stage1[12]
+ stage2[24]
+ inv
Xs3_24
+ vdd
+ vss
+ stage2[24]
+ stage3[24]
+ inv
Xs2_25_0
+ vdd
+ vss
+ stage1[12]
+ stage2[25]
+ inv
Xs2_25_1
+ vdd
+ vss
+ stage1[13]
+ stage2[25]
+ inv
Xs3_25
+ vdd
+ vss
+ stage2[25]
+ stage3[25]
+ inv
Xs2_26_0
+ vdd
+ vss
+ stage1[13]
+ stage2[26]
+ inv
Xs2_26_1
+ vdd
+ vss
+ stage1[13]
+ stage2[26]
+ inv
Xs3_26
+ vdd
+ vss
+ stage2[26]
+ stage3[26]
+ inv
Xs2_27_0
+ vdd
+ vss
+ stage1[13]
+ stage2[27]
+ inv
Xs2_27_1
+ vdd
+ vss
+ stage1[14]
+ stage2[27]
+ inv
Xs3_27
+ vdd
+ vss
+ stage2[27]
+ stage3[27]
+ inv
Xs2_28_0
+ vdd
+ vss
+ stage1[14]
+ stage2[28]
+ inv
Xs2_28_1
+ vdd
+ vss
+ stage1[14]
+ stage2[28]
+ inv
Xs3_28
+ vdd
+ vss
+ stage2[28]
+ stage3[28]
+ inv
Xs2_29_0
+ vdd
+ vss
+ stage1[14]
+ stage2[29]
+ inv
Xs2_29_1
+ vdd
+ vss
+ stage1[15]
+ stage2[29]
+ inv
Xs3_29
+ vdd
+ vss
+ stage2[29]
+ stage3[29]
+ inv
Xs2_30_0
+ vdd
+ vss
+ stage1[15]
+ stage2[30]
+ inv
Xs2_30_1
+ vdd
+ vss
+ stage1[15]
+ stage2[30]
+ inv
Xs3_30
+ vdd
+ vss
+ stage2[30]
+ stage3[30]
+ inv
Xs2_31_0
+ vdd
+ vss
+ stage1[15]
+ stage2[31]
+ inv
Xs2_31_1
+ vdd
+ vss
+ stage1[16]
+ stage2[31]
+ inv
Xs3_31
+ vdd
+ vss
+ stage2[31]
+ stage3[31]
+ inv
Xs2_32_0
+ vdd
+ vss
+ stage1[16]
+ stage2[32]
+ inv
Xs2_32_1
+ vdd
+ vss
+ stage1[16]
+ stage2[32]
+ inv
Xs3_32
+ vdd
+ vss
+ stage2[32]
+ stage3[32]
+ inv
Xs2_33_0
+ vdd
+ vss
+ stage1[16]
+ stage2[33]
+ inv
Xs2_33_1
+ vdd
+ vss
+ stage1[17]
+ stage2[33]
+ inv
Xs3_33
+ vdd
+ vss
+ stage2[33]
+ stage3[33]
+ inv
Xs2_34_0
+ vdd
+ vss
+ stage1[17]
+ stage2[34]
+ inv
Xs2_34_1
+ vdd
+ vss
+ stage1[17]
+ stage2[34]
+ inv
Xs3_34
+ vdd
+ vss
+ stage2[34]
+ stage3[34]
+ inv
Xs2_35_0
+ vdd
+ vss
+ stage1[17]
+ stage2[35]
+ inv
Xs2_35_1
+ vdd
+ vss
+ stage1[18]
+ stage2[35]
+ inv
Xs3_35
+ vdd
+ vss
+ stage2[35]
+ stage3[35]
+ inv
Xs2_36_0
+ vdd
+ vss
+ stage1[18]
+ stage2[36]
+ inv
Xs2_36_1
+ vdd
+ vss
+ stage1[18]
+ stage2[36]
+ inv
Xs3_36
+ vdd
+ vss
+ stage2[36]
+ stage3[36]
+ inv
Xs2_37_0
+ vdd
+ vss
+ stage1[18]
+ stage2[37]
+ inv
Xs2_37_1
+ vdd
+ vss
+ stage1[19]
+ stage2[37]
+ inv
Xs3_37
+ vdd
+ vss
+ stage2[37]
+ stage3[37]
+ inv
Xs2_38_0
+ vdd
+ vss
+ stage1[19]
+ stage2[38]
+ inv
Xs2_38_1
+ vdd
+ vss
+ stage1[19]
+ stage2[38]
+ inv
Xs3_38
+ vdd
+ vss
+ stage2[38]
+ stage3[38]
+ inv
Xs2_39_0
+ vdd
+ vss
+ stage1[19]
+ stage2[39]
+ inv
Xs2_39_1
+ vdd
+ vss
+ stage1[20]
+ stage2[39]
+ inv
Xs3_39
+ vdd
+ vss
+ stage2[39]
+ stage3[39]
+ inv
Xs2_40_0
+ vdd
+ vss
+ stage1[20]
+ stage2[40]
+ inv
Xs2_40_1
+ vdd
+ vss
+ stage1[20]
+ stage2[40]
+ inv
Xs3_40
+ vdd
+ vss
+ stage2[40]
+ stage3[40]
+ inv
Xs2_41_0
+ vdd
+ vss
+ stage1[20]
+ stage2[41]
+ inv
Xs2_41_1
+ vdd
+ vss
+ stage1[21]
+ stage2[41]
+ inv
Xs3_41
+ vdd
+ vss
+ stage2[41]
+ stage3[41]
+ inv
Xs2_42_0
+ vdd
+ vss
+ stage1[21]
+ stage2[42]
+ inv
Xs2_42_1
+ vdd
+ vss
+ stage1[21]
+ stage2[42]
+ inv
Xs3_42
+ vdd
+ vss
+ stage2[42]
+ stage3[42]
+ inv
Xs2_43_0
+ vdd
+ vss
+ stage1[21]
+ stage2[43]
+ inv
Xs2_43_1
+ vdd
+ vss
+ stage1[22]
+ stage2[43]
+ inv
Xs3_43
+ vdd
+ vss
+ stage2[43]
+ stage3[43]
+ inv
Xs2_44_0
+ vdd
+ vss
+ stage1[22]
+ stage2[44]
+ inv
Xs2_44_1
+ vdd
+ vss
+ stage1[22]
+ stage2[44]
+ inv
Xs3_44
+ vdd
+ vss
+ stage2[44]
+ stage3[44]
+ inv
Xs2_45_0
+ vdd
+ vss
+ stage1[22]
+ stage2[45]
+ inv
Xs2_45_1
+ vdd
+ vss
+ stage1[23]
+ stage2[45]
+ inv
Xs3_45
+ vdd
+ vss
+ stage2[45]
+ stage3[45]
+ inv
Xs2_46_0
+ vdd
+ vss
+ stage1[23]
+ stage2[46]
+ inv
Xs2_46_1
+ vdd
+ vss
+ stage1[23]
+ stage2[46]
+ inv
Xs3_46
+ vdd
+ vss
+ stage2[46]
+ stage3[46]
+ inv
Xs2_47_0
+ vdd
+ vss
+ stage1[23]
+ stage2[47]
+ inv
Xs2_47_1
+ vdd
+ vss
+ stage1[24]
+ stage2[47]
+ inv
Xs3_47
+ vdd
+ vss
+ stage2[47]
+ stage3[47]
+ inv
Xs2_48_0
+ vdd
+ vss
+ stage1[24]
+ stage2[48]
+ inv
Xs2_48_1
+ vdd
+ vss
+ stage1[24]
+ stage2[48]
+ inv
Xs3_48
+ vdd
+ vss
+ stage2[48]
+ stage3[48]
+ inv
Xs2_49_0
+ vdd
+ vss
+ stage1[24]
+ stage2[49]
+ inv
Xs2_49_1
+ vdd
+ vss
+ stage1[25]
+ stage2[49]
+ inv
Xs3_49
+ vdd
+ vss
+ stage2[49]
+ stage3[49]
+ inv
Xs2_50_0
+ vdd
+ vss
+ stage1[25]
+ stage2[50]
+ inv
Xs2_50_1
+ vdd
+ vss
+ stage1[25]
+ stage2[50]
+ inv
Xs3_50
+ vdd
+ vss
+ stage2[50]
+ stage3[50]
+ inv
Xs2_51_0
+ vdd
+ vss
+ stage1[25]
+ stage2[51]
+ inv
Xs2_51_1
+ vdd
+ vss
+ stage1[26]
+ stage2[51]
+ inv
Xs3_51
+ vdd
+ vss
+ stage2[51]
+ stage3[51]
+ inv
Xs2_52_0
+ vdd
+ vss
+ stage1[26]
+ stage2[52]
+ inv
Xs2_52_1
+ vdd
+ vss
+ stage1[26]
+ stage2[52]
+ inv
Xs3_52
+ vdd
+ vss
+ stage2[52]
+ stage3[52]
+ inv
Xs2_53_0
+ vdd
+ vss
+ stage1[26]
+ stage2[53]
+ inv
Xs2_53_1
+ vdd
+ vss
+ stage1[27]
+ stage2[53]
+ inv
Xs3_53
+ vdd
+ vss
+ stage2[53]
+ stage3[53]
+ inv
Xs2_54_0
+ vdd
+ vss
+ stage1[27]
+ stage2[54]
+ inv
Xs2_54_1
+ vdd
+ vss
+ stage1[27]
+ stage2[54]
+ inv
Xs3_54
+ vdd
+ vss
+ stage2[54]
+ stage3[54]
+ inv
Xs2_55_0
+ vdd
+ vss
+ stage1[27]
+ stage2[55]
+ inv
Xs2_55_1
+ vdd
+ vss
+ stage1[28]
+ stage2[55]
+ inv
Xs3_55
+ vdd
+ vss
+ stage2[55]
+ stage3[55]
+ inv
Xs2_56_0
+ vdd
+ vss
+ stage1[28]
+ stage2[56]
+ inv
Xs2_56_1
+ vdd
+ vss
+ stage1[28]
+ stage2[56]
+ inv
Xs3_56
+ vdd
+ vss
+ stage2[56]
+ stage3[56]
+ inv
Xs2_57_0
+ vdd
+ vss
+ stage1[28]
+ stage2[57]
+ inv
Xs2_57_1
+ vdd
+ vss
+ stage1[29]
+ stage2[57]
+ inv
Xs3_57
+ vdd
+ vss
+ stage2[57]
+ stage3[57]
+ inv
Xs2_58_0
+ vdd
+ vss
+ stage1[29]
+ stage2[58]
+ inv
Xs2_58_1
+ vdd
+ vss
+ stage1[29]
+ stage2[58]
+ inv
Xs3_58
+ vdd
+ vss
+ stage2[58]
+ stage3[58]
+ inv
Xs2_59_0
+ vdd
+ vss
+ stage1[29]
+ stage2[59]
+ inv
Xs2_59_1
+ vdd
+ vss
+ stage1[30]
+ stage2[59]
+ inv
Xs3_59
+ vdd
+ vss
+ stage2[59]
+ stage3[59]
+ inv
Xs2_60_0
+ vdd
+ vss
+ stage1[30]
+ stage2[60]
+ inv
Xs2_60_1
+ vdd
+ vss
+ stage1[30]
+ stage2[60]
+ inv
Xs3_60
+ vdd
+ vss
+ stage2[60]
+ stage3[60]
+ inv
Xs2_61_0
+ vdd
+ vss
+ stage1[30]
+ stage2[61]
+ inv
Xs2_61_1
+ vdd
+ vss
+ stage1[31]
+ stage2[61]
+ inv
Xs3_61
+ vdd
+ vss
+ stage2[61]
+ stage3[61]
+ inv
Xs2_62_0
+ vdd
+ vss
+ stage1[31]
+ stage2[62]
+ inv
Xs2_62_1
+ vdd
+ vss
+ stage1[31]
+ stage2[62]
+ inv
Xs3_62
+ vdd
+ vss
+ stage2[62]
+ stage3[62]
+ inv
Xs2_63_0
+ vdd
+ vss
+ stage1[31]
+ stage2[63]
+ inv
Xs2_63_1
+ vdd
+ vss
+ stage1[32]
+ stage2[63]
+ inv
Xs3_63
+ vdd
+ vss
+ stage2[63]
+ stage3[63]
+ inv
Xs2_64_0
+ vdd
+ vss
+ stage1[32]
+ stage2[64]
+ inv
Xs2_64_1
+ vdd
+ vss
+ stage1[32]
+ stage2[64]
+ inv
Xs3_64
+ vdd
+ vss
+ stage2[64]
+ stage3[64]
+ inv
Xs2_65_0
+ vdd
+ vss
+ stage1[32]
+ stage2[65]
+ inv
Xs2_65_1
+ vdd
+ vss
+ stage1[33]
+ stage2[65]
+ inv
Xs3_65
+ vdd
+ vss
+ stage2[65]
+ stage3[65]
+ inv
Xs2_66_0
+ vdd
+ vss
+ stage1[33]
+ stage2[66]
+ inv
Xs2_66_1
+ vdd
+ vss
+ stage1[33]
+ stage2[66]
+ inv
Xs3_66
+ vdd
+ vss
+ stage2[66]
+ stage3[66]
+ inv
Xs2_67_0
+ vdd
+ vss
+ stage1[33]
+ stage2[67]
+ inv
Xs2_67_1
+ vdd
+ vss
+ stage1[34]
+ stage2[67]
+ inv
Xs3_67
+ vdd
+ vss
+ stage2[67]
+ stage3[67]
+ inv
Xs2_68_0
+ vdd
+ vss
+ stage1[34]
+ stage2[68]
+ inv
Xs2_68_1
+ vdd
+ vss
+ stage1[34]
+ stage2[68]
+ inv
Xs3_68
+ vdd
+ vss
+ stage2[68]
+ stage3[68]
+ inv
Xs2_69_0
+ vdd
+ vss
+ stage1[34]
+ stage2[69]
+ inv
Xs2_69_1
+ vdd
+ vss
+ stage1[35]
+ stage2[69]
+ inv
Xs3_69
+ vdd
+ vss
+ stage2[69]
+ stage3[69]
+ inv
Xs2_70_0
+ vdd
+ vss
+ stage1[35]
+ stage2[70]
+ inv
Xs2_70_1
+ vdd
+ vss
+ stage1[35]
+ stage2[70]
+ inv
Xs3_70
+ vdd
+ vss
+ stage2[70]
+ stage3[70]
+ inv
Xs2_71_0
+ vdd
+ vss
+ stage1[35]
+ stage2[71]
+ inv
Xs2_71_1
+ vdd
+ vss
+ stage1[36]
+ stage2[71]
+ inv
Xs3_71
+ vdd
+ vss
+ stage2[71]
+ stage3[71]
+ inv
Xs2_72_0
+ vdd
+ vss
+ stage1[36]
+ stage2[72]
+ inv
Xs2_72_1
+ vdd
+ vss
+ stage1[36]
+ stage2[72]
+ inv
Xs3_72
+ vdd
+ vss
+ stage2[72]
+ stage3[72]
+ inv
Xs2_73_0
+ vdd
+ vss
+ stage1[36]
+ stage2[73]
+ inv
Xs2_73_1
+ vdd
+ vss
+ stage1[37]
+ stage2[73]
+ inv
Xs3_73
+ vdd
+ vss
+ stage2[73]
+ stage3[73]
+ inv
Xs2_74_0
+ vdd
+ vss
+ stage1[37]
+ stage2[74]
+ inv
Xs2_74_1
+ vdd
+ vss
+ stage1[37]
+ stage2[74]
+ inv
Xs3_74
+ vdd
+ vss
+ stage2[74]
+ stage3[74]
+ inv
Xs2_75_0
+ vdd
+ vss
+ stage1[37]
+ stage2[75]
+ inv
Xs2_75_1
+ vdd
+ vss
+ stage1[38]
+ stage2[75]
+ inv
Xs3_75
+ vdd
+ vss
+ stage2[75]
+ stage3[75]
+ inv
Xs2_76_0
+ vdd
+ vss
+ stage1[38]
+ stage2[76]
+ inv
Xs2_76_1
+ vdd
+ vss
+ stage1[38]
+ stage2[76]
+ inv
Xs3_76
+ vdd
+ vss
+ stage2[76]
+ stage3[76]
+ inv
Xs2_77_0
+ vdd
+ vss
+ stage1[38]
+ stage2[77]
+ inv
Xs2_77_1
+ vdd
+ vss
+ stage1[39]
+ stage2[77]
+ inv
Xs3_77
+ vdd
+ vss
+ stage2[77]
+ stage3[77]
+ inv
Xs2_78_0
+ vdd
+ vss
+ stage1[39]
+ stage2[78]
+ inv
Xs2_78_1
+ vdd
+ vss
+ stage1[39]
+ stage2[78]
+ inv
Xs3_78
+ vdd
+ vss
+ stage2[78]
+ stage3[78]
+ inv
Xs2_79_0
+ vdd
+ vss
+ stage1[39]
+ stage2[79]
+ inv
Xs2_79_1
+ vdd
+ vss
+ stage1[40]
+ stage2[79]
+ inv
Xs3_79
+ vdd
+ vss
+ stage2[79]
+ stage3[79]
+ inv
Xs2_80_0
+ vdd
+ vss
+ stage1[40]
+ stage2[80]
+ inv
Xs2_80_1
+ vdd
+ vss
+ stage1[40]
+ stage2[80]
+ inv
Xs3_80
+ vdd
+ vss
+ stage2[80]
+ stage3[80]
+ inv
Xs2_81_0
+ vdd
+ vss
+ stage1[40]
+ stage2[81]
+ inv
Xs2_81_1
+ vdd
+ vss
+ stage1[41]
+ stage2[81]
+ inv
Xs3_81
+ vdd
+ vss
+ stage2[81]
+ stage3[81]
+ inv
Xs2_82_0
+ vdd
+ vss
+ stage1[41]
+ stage2[82]
+ inv
Xs2_82_1
+ vdd
+ vss
+ stage1[41]
+ stage2[82]
+ inv
Xs3_82
+ vdd
+ vss
+ stage2[82]
+ stage3[82]
+ inv
Xs2_83_0
+ vdd
+ vss
+ stage1[41]
+ stage2[83]
+ inv
Xs2_83_1
+ vdd
+ vss
+ stage1[42]
+ stage2[83]
+ inv
Xs3_83
+ vdd
+ vss
+ stage2[83]
+ stage3[83]
+ inv
Xs2_84_0
+ vdd
+ vss
+ stage1[42]
+ stage2[84]
+ inv
Xs2_84_1
+ vdd
+ vss
+ stage1[42]
+ stage2[84]
+ inv
Xs3_84
+ vdd
+ vss
+ stage2[84]
+ stage3[84]
+ inv
Xs2_85_0
+ vdd
+ vss
+ stage1[42]
+ stage2[85]
+ inv
Xs2_85_1
+ vdd
+ vss
+ stage1[43]
+ stage2[85]
+ inv
Xs3_85
+ vdd
+ vss
+ stage2[85]
+ stage3[85]
+ inv
Xs2_86_0
+ vdd
+ vss
+ stage1[43]
+ stage2[86]
+ inv
Xs2_86_1
+ vdd
+ vss
+ stage1[43]
+ stage2[86]
+ inv
Xs3_86
+ vdd
+ vss
+ stage2[86]
+ stage3[86]
+ inv
Xs2_87_0
+ vdd
+ vss
+ stage1[43]
+ stage2[87]
+ inv
Xs2_87_1
+ vdd
+ vss
+ stage1[44]
+ stage2[87]
+ inv
Xs3_87
+ vdd
+ vss
+ stage2[87]
+ stage3[87]
+ inv
Xs2_88_0
+ vdd
+ vss
+ stage1[44]
+ stage2[88]
+ inv
Xs2_88_1
+ vdd
+ vss
+ stage1[44]
+ stage2[88]
+ inv
Xs3_88
+ vdd
+ vss
+ stage2[88]
+ stage3[88]
+ inv
Xs2_89_0
+ vdd
+ vss
+ stage1[44]
+ stage2[89]
+ inv
Xs2_89_1
+ vdd
+ vss
+ stage1[45]
+ stage2[89]
+ inv
Xs3_89
+ vdd
+ vss
+ stage2[89]
+ stage3[89]
+ inv
Xs2_90_0
+ vdd
+ vss
+ stage1[45]
+ stage2[90]
+ inv
Xs2_90_1
+ vdd
+ vss
+ stage1[45]
+ stage2[90]
+ inv
Xs3_90
+ vdd
+ vss
+ stage2[90]
+ stage3[90]
+ inv
Xs2_91_0
+ vdd
+ vss
+ stage1[45]
+ stage2[91]
+ inv
Xs2_91_1
+ vdd
+ vss
+ stage1[46]
+ stage2[91]
+ inv
Xs3_91
+ vdd
+ vss
+ stage2[91]
+ stage3[91]
+ inv
Xs2_92_0
+ vdd
+ vss
+ stage1[46]
+ stage2[92]
+ inv
Xs2_92_1
+ vdd
+ vss
+ stage1[46]
+ stage2[92]
+ inv
Xs3_92
+ vdd
+ vss
+ stage2[92]
+ stage3[92]
+ inv
Xs2_93_0
+ vdd
+ vss
+ stage1[46]
+ stage2[93]
+ inv
Xs2_93_1
+ vdd
+ vss
+ stage1[47]
+ stage2[93]
+ inv
Xs3_93
+ vdd
+ vss
+ stage2[93]
+ stage3[93]
+ inv
Xs2_94_0
+ vdd
+ vss
+ stage1[47]
+ stage2[94]
+ inv
Xs2_94_1
+ vdd
+ vss
+ stage1[47]
+ stage2[94]
+ inv
Xs3_94
+ vdd
+ vss
+ stage2[94]
+ stage3[94]
+ inv
Xs2_95_0
+ vdd
+ vss
+ stage1[47]
+ stage2[95]
+ inv
Xs2_95_1
+ vdd
+ vss
+ stage1[48]
+ stage2[95]
+ inv
Xs3_95
+ vdd
+ vss
+ stage2[95]
+ stage3[95]
+ inv
Xs2_96_0
+ vdd
+ vss
+ stage1[48]
+ stage2[96]
+ inv
Xs2_96_1
+ vdd
+ vss
+ stage1[48]
+ stage2[96]
+ inv
Xs3_96
+ vdd
+ vss
+ stage2[96]
+ stage3[96]
+ inv
Xs2_97_0
+ vdd
+ vss
+ stage1[48]
+ stage2[97]
+ inv
Xs2_97_1
+ vdd
+ vss
+ stage1[49]
+ stage2[97]
+ inv
Xs3_97
+ vdd
+ vss
+ stage2[97]
+ stage3[97]
+ inv
Xs2_98_0
+ vdd
+ vss
+ stage1[49]
+ stage2[98]
+ inv
Xs2_98_1
+ vdd
+ vss
+ stage1[49]
+ stage2[98]
+ inv
Xs3_98
+ vdd
+ vss
+ stage2[98]
+ stage3[98]
+ inv
Xs2_99_0
+ vdd
+ vss
+ stage1[49]
+ stage2[99]
+ inv
Xs2_99_1
+ vdd
+ vss
+ stage1[50]
+ stage2[99]
+ inv
Xs3_99
+ vdd
+ vss
+ stage2[99]
+ stage3[99]
+ inv
Xs2_100_0
+ vdd
+ vss
+ stage1[50]
+ stage2[100]
+ inv
Xs2_100_1
+ vdd
+ vss
+ stage1[50]
+ stage2[100]
+ inv
Xs3_100
+ vdd
+ vss
+ stage2[100]
+ stage3[100]
+ inv
Xs2_101_0
+ vdd
+ vss
+ stage1[50]
+ stage2[101]
+ inv
Xs2_101_1
+ vdd
+ vss
+ stage1[51]
+ stage2[101]
+ inv
Xs3_101
+ vdd
+ vss
+ stage2[101]
+ stage3[101]
+ inv
Xs2_102_0
+ vdd
+ vss
+ stage1[51]
+ stage2[102]
+ inv
Xs2_102_1
+ vdd
+ vss
+ stage1[51]
+ stage2[102]
+ inv
Xs3_102
+ vdd
+ vss
+ stage2[102]
+ stage3[102]
+ inv
Xs2_103_0
+ vdd
+ vss
+ stage1[51]
+ stage2[103]
+ inv
Xs2_103_1
+ vdd
+ vss
+ stage1[52]
+ stage2[103]
+ inv
Xs3_103
+ vdd
+ vss
+ stage2[103]
+ stage3[103]
+ inv
Xs2_104_0
+ vdd
+ vss
+ stage1[52]
+ stage2[104]
+ inv
Xs2_104_1
+ vdd
+ vss
+ stage1[52]
+ stage2[104]
+ inv
Xs3_104
+ vdd
+ vss
+ stage2[104]
+ stage3[104]
+ inv
Xs2_105_0
+ vdd
+ vss
+ stage1[52]
+ stage2[105]
+ inv
Xs2_105_1
+ vdd
+ vss
+ stage1[53]
+ stage2[105]
+ inv
Xs3_105
+ vdd
+ vss
+ stage2[105]
+ stage3[105]
+ inv
Xs2_106_0
+ vdd
+ vss
+ stage1[53]
+ stage2[106]
+ inv
Xs2_106_1
+ vdd
+ vss
+ stage1[53]
+ stage2[106]
+ inv
Xs3_106
+ vdd
+ vss
+ stage2[106]
+ stage3[106]
+ inv
Xs2_107_0
+ vdd
+ vss
+ stage1[53]
+ stage2[107]
+ inv
Xs2_107_1
+ vdd
+ vss
+ stage1[54]
+ stage2[107]
+ inv
Xs3_107
+ vdd
+ vss
+ stage2[107]
+ stage3[107]
+ inv
Xs2_108_0
+ vdd
+ vss
+ stage1[54]
+ stage2[108]
+ inv
Xs2_108_1
+ vdd
+ vss
+ stage1[54]
+ stage2[108]
+ inv
Xs3_108
+ vdd
+ vss
+ stage2[108]
+ stage3[108]
+ inv
Xs2_109_0
+ vdd
+ vss
+ stage1[54]
+ stage2[109]
+ inv
Xs2_109_1
+ vdd
+ vss
+ stage1[55]
+ stage2[109]
+ inv
Xs3_109
+ vdd
+ vss
+ stage2[109]
+ stage3[109]
+ inv
Xs2_110_0
+ vdd
+ vss
+ stage1[55]
+ stage2[110]
+ inv
Xs2_110_1
+ vdd
+ vss
+ stage1[55]
+ stage2[110]
+ inv
Xs3_110
+ vdd
+ vss
+ stage2[110]
+ stage3[110]
+ inv
Xs2_111_0
+ vdd
+ vss
+ stage1[55]
+ stage2[111]
+ inv
Xs2_111_1
+ vdd
+ vss
+ stage1[56]
+ stage2[111]
+ inv
Xs3_111
+ vdd
+ vss
+ stage2[111]
+ stage3[111]
+ inv
Xs2_112_0
+ vdd
+ vss
+ stage1[56]
+ stage2[112]
+ inv
Xs2_112_1
+ vdd
+ vss
+ stage1[56]
+ stage2[112]
+ inv
Xs3_112
+ vdd
+ vss
+ stage2[112]
+ stage3[112]
+ inv
Xs2_113_0
+ vdd
+ vss
+ stage1[56]
+ stage2[113]
+ inv
Xs2_113_1
+ vdd
+ vss
+ stage1[57]
+ stage2[113]
+ inv
Xs3_113
+ vdd
+ vss
+ stage2[113]
+ stage3[113]
+ inv
Xs2_114_0
+ vdd
+ vss
+ stage1[57]
+ stage2[114]
+ inv
Xs2_114_1
+ vdd
+ vss
+ stage1[57]
+ stage2[114]
+ inv
Xs3_114
+ vdd
+ vss
+ stage2[114]
+ stage3[114]
+ inv
Xs2_115_0
+ vdd
+ vss
+ stage1[57]
+ stage2[115]
+ inv
Xs2_115_1
+ vdd
+ vss
+ stage1[58]
+ stage2[115]
+ inv
Xs3_115
+ vdd
+ vss
+ stage2[115]
+ stage3[115]
+ inv
Xs2_116_0
+ vdd
+ vss
+ stage1[58]
+ stage2[116]
+ inv
Xs2_116_1
+ vdd
+ vss
+ stage1[58]
+ stage2[116]
+ inv
Xs3_116
+ vdd
+ vss
+ stage2[116]
+ stage3[116]
+ inv
Xs2_117_0
+ vdd
+ vss
+ stage1[58]
+ stage2[117]
+ inv
Xs2_117_1
+ vdd
+ vss
+ stage1[59]
+ stage2[117]
+ inv
Xs3_117
+ vdd
+ vss
+ stage2[117]
+ stage3[117]
+ inv
Xs2_118_0
+ vdd
+ vss
+ stage1[59]
+ stage2[118]
+ inv
Xs2_118_1
+ vdd
+ vss
+ stage1[59]
+ stage2[118]
+ inv
Xs3_118
+ vdd
+ vss
+ stage2[118]
+ stage3[118]
+ inv
Xs2_119_0
+ vdd
+ vss
+ stage1[59]
+ stage2[119]
+ inv
Xs2_119_1
+ vdd
+ vss
+ stage1[60]
+ stage2[119]
+ inv
Xs3_119
+ vdd
+ vss
+ stage2[119]
+ stage3[119]
+ inv
Xs2_120_0
+ vdd
+ vss
+ stage1[60]
+ stage2[120]
+ inv
Xs2_120_1
+ vdd
+ vss
+ stage1[60]
+ stage2[120]
+ inv
Xs3_120
+ vdd
+ vss
+ stage2[120]
+ stage3[120]
+ inv
Xs2_121_0
+ vdd
+ vss
+ stage1[60]
+ stage2[121]
+ inv
Xs2_121_1
+ vdd
+ vss
+ stage1[61]
+ stage2[121]
+ inv
Xs3_121
+ vdd
+ vss
+ stage2[121]
+ stage3[121]
+ inv
Xs2_122_0
+ vdd
+ vss
+ stage1[61]
+ stage2[122]
+ inv
Xs2_122_1
+ vdd
+ vss
+ stage1[61]
+ stage2[122]
+ inv
Xs3_122
+ vdd
+ vss
+ stage2[122]
+ stage3[122]
+ inv
Xs2_123_0
+ vdd
+ vss
+ stage1[61]
+ stage2[123]
+ inv
Xs2_123_1
+ vdd
+ vss
+ stage1[62]
+ stage2[123]
+ inv
Xs3_123
+ vdd
+ vss
+ stage2[123]
+ stage3[123]
+ inv
Xs2_124_0
+ vdd
+ vss
+ stage1[62]
+ stage2[124]
+ inv
Xs2_124_1
+ vdd
+ vss
+ stage1[62]
+ stage2[124]
+ inv
Xs3_124
+ vdd
+ vss
+ stage2[124]
+ stage3[124]
+ inv
Xs2_125_0
+ vdd
+ vss
+ stage1[62]
+ stage2[125]
+ inv
Xs2_125_1
+ vdd
+ vss
+ stage1[63]
+ stage2[125]
+ inv
Xs3_125
+ vdd
+ vss
+ stage2[125]
+ stage3[125]
+ inv
Xs2_126_0
+ vdd
+ vss
+ stage1[63]
+ stage2[126]
+ inv
Xs2_126_1
+ vdd
+ vss
+ stage1[63]
+ stage2[126]
+ inv
Xs3_126
+ vdd
+ vss
+ stage2[126]
+ stage3[126]
+ inv
Xs2_dummy_0
+ vdd
+ vss
+ stage1[0]
+ tmp[0]
+ inv
Xs2_dummy_1
+ vdd
+ vss
+ stage1[63]
+ tmp[1]
+ inv
Xs4_dummy_0
+ vdd
+ vss
+ stage3[0]
+ tmp[2]
+ inv
Xs4_dummy_1
+ vdd
+ vss
+ stage3[126]
+ tmp[3]
+ inv
Xs4_dummy_2
+ vdd
+ vss
+ stage3[126]
+ tmp[4]
+ inv
Xs4_dummy_3
+ vdd
+ vss
+ stage3[126]
+ tmp[5]
+ inv
Xs4_0_0
+ vdd
+ vss
+ stage3[0]
+ stage4[0]
+ inv
Xs4_0_1
+ vdd
+ vss
+ stage3[0]
+ stage4[0]
+ inv
Xs5_0
+ vdd
+ vss
+ stage4[0]
+ stage5[0]
+ inv
Xff_0
+ b
+ stage5[0]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[0]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_1_0
+ vdd
+ vss
+ stage3[0]
+ stage4[1]
+ inv
Xs4_1_1
+ vdd
+ vss
+ stage3[1]
+ stage4[1]
+ inv
Xs5_1
+ vdd
+ vss
+ stage4[1]
+ stage5[1]
+ inv
Xff_1
+ b
+ stage5[1]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[1]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_2_0
+ vdd
+ vss
+ stage3[1]
+ stage4[2]
+ inv
Xs4_2_1
+ vdd
+ vss
+ stage3[1]
+ stage4[2]
+ inv
Xs5_2
+ vdd
+ vss
+ stage4[2]
+ stage5[2]
+ inv
Xff_2
+ b
+ stage5[2]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[2]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_3_0
+ vdd
+ vss
+ stage3[1]
+ stage4[3]
+ inv
Xs4_3_1
+ vdd
+ vss
+ stage3[2]
+ stage4[3]
+ inv
Xs5_3
+ vdd
+ vss
+ stage4[3]
+ stage5[3]
+ inv
Xff_3
+ b
+ stage5[3]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[3]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_4_0
+ vdd
+ vss
+ stage3[2]
+ stage4[4]
+ inv
Xs4_4_1
+ vdd
+ vss
+ stage3[2]
+ stage4[4]
+ inv
Xs5_4
+ vdd
+ vss
+ stage4[4]
+ stage5[4]
+ inv
Xff_4
+ b
+ stage5[4]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[4]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_5_0
+ vdd
+ vss
+ stage3[2]
+ stage4[5]
+ inv
Xs4_5_1
+ vdd
+ vss
+ stage3[3]
+ stage4[5]
+ inv
Xs5_5
+ vdd
+ vss
+ stage4[5]
+ stage5[5]
+ inv
Xff_5
+ b
+ stage5[5]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[5]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_6_0
+ vdd
+ vss
+ stage3[3]
+ stage4[6]
+ inv
Xs4_6_1
+ vdd
+ vss
+ stage3[3]
+ stage4[6]
+ inv
Xs5_6
+ vdd
+ vss
+ stage4[6]
+ stage5[6]
+ inv
Xff_6
+ b
+ stage5[6]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[6]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_7_0
+ vdd
+ vss
+ stage3[3]
+ stage4[7]
+ inv
Xs4_7_1
+ vdd
+ vss
+ stage3[4]
+ stage4[7]
+ inv
Xs5_7
+ vdd
+ vss
+ stage4[7]
+ stage5[7]
+ inv
Xff_7
+ b
+ stage5[7]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[7]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_8_0
+ vdd
+ vss
+ stage3[4]
+ stage4[8]
+ inv
Xs4_8_1
+ vdd
+ vss
+ stage3[4]
+ stage4[8]
+ inv
Xs5_8
+ vdd
+ vss
+ stage4[8]
+ stage5[8]
+ inv
Xff_8
+ b
+ stage5[8]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[8]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_9_0
+ vdd
+ vss
+ stage3[4]
+ stage4[9]
+ inv
Xs4_9_1
+ vdd
+ vss
+ stage3[5]
+ stage4[9]
+ inv
Xs5_9
+ vdd
+ vss
+ stage4[9]
+ stage5[9]
+ inv
Xff_9
+ b
+ stage5[9]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[9]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_10_0
+ vdd
+ vss
+ stage3[5]
+ stage4[10]
+ inv
Xs4_10_1
+ vdd
+ vss
+ stage3[5]
+ stage4[10]
+ inv
Xs5_10
+ vdd
+ vss
+ stage4[10]
+ stage5[10]
+ inv
Xff_10
+ b
+ stage5[10]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[10]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_11_0
+ vdd
+ vss
+ stage3[5]
+ stage4[11]
+ inv
Xs4_11_1
+ vdd
+ vss
+ stage3[6]
+ stage4[11]
+ inv
Xs5_11
+ vdd
+ vss
+ stage4[11]
+ stage5[11]
+ inv
Xff_11
+ b
+ stage5[11]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[11]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_12_0
+ vdd
+ vss
+ stage3[6]
+ stage4[12]
+ inv
Xs4_12_1
+ vdd
+ vss
+ stage3[6]
+ stage4[12]
+ inv
Xs5_12
+ vdd
+ vss
+ stage4[12]
+ stage5[12]
+ inv
Xff_12
+ b
+ stage5[12]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[12]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_13_0
+ vdd
+ vss
+ stage3[6]
+ stage4[13]
+ inv
Xs4_13_1
+ vdd
+ vss
+ stage3[7]
+ stage4[13]
+ inv
Xs5_13
+ vdd
+ vss
+ stage4[13]
+ stage5[13]
+ inv
Xff_13
+ b
+ stage5[13]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[13]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_14_0
+ vdd
+ vss
+ stage3[7]
+ stage4[14]
+ inv
Xs4_14_1
+ vdd
+ vss
+ stage3[7]
+ stage4[14]
+ inv
Xs5_14
+ vdd
+ vss
+ stage4[14]
+ stage5[14]
+ inv
Xff_14
+ b
+ stage5[14]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[14]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_15_0
+ vdd
+ vss
+ stage3[7]
+ stage4[15]
+ inv
Xs4_15_1
+ vdd
+ vss
+ stage3[8]
+ stage4[15]
+ inv
Xs5_15
+ vdd
+ vss
+ stage4[15]
+ stage5[15]
+ inv
Xff_15
+ b
+ stage5[15]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[15]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_16_0
+ vdd
+ vss
+ stage3[8]
+ stage4[16]
+ inv
Xs4_16_1
+ vdd
+ vss
+ stage3[8]
+ stage4[16]
+ inv
Xs5_16
+ vdd
+ vss
+ stage4[16]
+ stage5[16]
+ inv
Xff_16
+ b
+ stage5[16]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[16]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_17_0
+ vdd
+ vss
+ stage3[8]
+ stage4[17]
+ inv
Xs4_17_1
+ vdd
+ vss
+ stage3[9]
+ stage4[17]
+ inv
Xs5_17
+ vdd
+ vss
+ stage4[17]
+ stage5[17]
+ inv
Xff_17
+ b
+ stage5[17]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[17]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_18_0
+ vdd
+ vss
+ stage3[9]
+ stage4[18]
+ inv
Xs4_18_1
+ vdd
+ vss
+ stage3[9]
+ stage4[18]
+ inv
Xs5_18
+ vdd
+ vss
+ stage4[18]
+ stage5[18]
+ inv
Xff_18
+ b
+ stage5[18]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[18]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_19_0
+ vdd
+ vss
+ stage3[9]
+ stage4[19]
+ inv
Xs4_19_1
+ vdd
+ vss
+ stage3[10]
+ stage4[19]
+ inv
Xs5_19
+ vdd
+ vss
+ stage4[19]
+ stage5[19]
+ inv
Xff_19
+ b
+ stage5[19]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[19]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_20_0
+ vdd
+ vss
+ stage3[10]
+ stage4[20]
+ inv
Xs4_20_1
+ vdd
+ vss
+ stage3[10]
+ stage4[20]
+ inv
Xs5_20
+ vdd
+ vss
+ stage4[20]
+ stage5[20]
+ inv
Xff_20
+ b
+ stage5[20]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[20]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_21_0
+ vdd
+ vss
+ stage3[10]
+ stage4[21]
+ inv
Xs4_21_1
+ vdd
+ vss
+ stage3[11]
+ stage4[21]
+ inv
Xs5_21
+ vdd
+ vss
+ stage4[21]
+ stage5[21]
+ inv
Xff_21
+ b
+ stage5[21]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[21]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_22_0
+ vdd
+ vss
+ stage3[11]
+ stage4[22]
+ inv
Xs4_22_1
+ vdd
+ vss
+ stage3[11]
+ stage4[22]
+ inv
Xs5_22
+ vdd
+ vss
+ stage4[22]
+ stage5[22]
+ inv
Xff_22
+ b
+ stage5[22]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[22]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_23_0
+ vdd
+ vss
+ stage3[11]
+ stage4[23]
+ inv
Xs4_23_1
+ vdd
+ vss
+ stage3[12]
+ stage4[23]
+ inv
Xs5_23
+ vdd
+ vss
+ stage4[23]
+ stage5[23]
+ inv
Xff_23
+ b
+ stage5[23]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[23]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_24_0
+ vdd
+ vss
+ stage3[12]
+ stage4[24]
+ inv
Xs4_24_1
+ vdd
+ vss
+ stage3[12]
+ stage4[24]
+ inv
Xs5_24
+ vdd
+ vss
+ stage4[24]
+ stage5[24]
+ inv
Xff_24
+ b
+ stage5[24]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[24]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_25_0
+ vdd
+ vss
+ stage3[12]
+ stage4[25]
+ inv
Xs4_25_1
+ vdd
+ vss
+ stage3[13]
+ stage4[25]
+ inv
Xs5_25
+ vdd
+ vss
+ stage4[25]
+ stage5[25]
+ inv
Xff_25
+ b
+ stage5[25]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[25]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_26_0
+ vdd
+ vss
+ stage3[13]
+ stage4[26]
+ inv
Xs4_26_1
+ vdd
+ vss
+ stage3[13]
+ stage4[26]
+ inv
Xs5_26
+ vdd
+ vss
+ stage4[26]
+ stage5[26]
+ inv
Xff_26
+ b
+ stage5[26]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[26]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_27_0
+ vdd
+ vss
+ stage3[13]
+ stage4[27]
+ inv
Xs4_27_1
+ vdd
+ vss
+ stage3[14]
+ stage4[27]
+ inv
Xs5_27
+ vdd
+ vss
+ stage4[27]
+ stage5[27]
+ inv
Xff_27
+ b
+ stage5[27]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[27]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_28_0
+ vdd
+ vss
+ stage3[14]
+ stage4[28]
+ inv
Xs4_28_1
+ vdd
+ vss
+ stage3[14]
+ stage4[28]
+ inv
Xs5_28
+ vdd
+ vss
+ stage4[28]
+ stage5[28]
+ inv
Xff_28
+ b
+ stage5[28]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[28]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_29_0
+ vdd
+ vss
+ stage3[14]
+ stage4[29]
+ inv
Xs4_29_1
+ vdd
+ vss
+ stage3[15]
+ stage4[29]
+ inv
Xs5_29
+ vdd
+ vss
+ stage4[29]
+ stage5[29]
+ inv
Xff_29
+ b
+ stage5[29]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[29]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_30_0
+ vdd
+ vss
+ stage3[15]
+ stage4[30]
+ inv
Xs4_30_1
+ vdd
+ vss
+ stage3[15]
+ stage4[30]
+ inv
Xs5_30
+ vdd
+ vss
+ stage4[30]
+ stage5[30]
+ inv
Xff_30
+ b
+ stage5[30]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[30]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_31_0
+ vdd
+ vss
+ stage3[15]
+ stage4[31]
+ inv
Xs4_31_1
+ vdd
+ vss
+ stage3[16]
+ stage4[31]
+ inv
Xs5_31
+ vdd
+ vss
+ stage4[31]
+ stage5[31]
+ inv
Xff_31
+ b
+ stage5[31]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[31]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_32_0
+ vdd
+ vss
+ stage3[16]
+ stage4[32]
+ inv
Xs4_32_1
+ vdd
+ vss
+ stage3[16]
+ stage4[32]
+ inv
Xs5_32
+ vdd
+ vss
+ stage4[32]
+ stage5[32]
+ inv
Xff_32
+ b
+ stage5[32]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[32]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_33_0
+ vdd
+ vss
+ stage3[16]
+ stage4[33]
+ inv
Xs4_33_1
+ vdd
+ vss
+ stage3[17]
+ stage4[33]
+ inv
Xs5_33
+ vdd
+ vss
+ stage4[33]
+ stage5[33]
+ inv
Xff_33
+ b
+ stage5[33]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[33]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_34_0
+ vdd
+ vss
+ stage3[17]
+ stage4[34]
+ inv
Xs4_34_1
+ vdd
+ vss
+ stage3[17]
+ stage4[34]
+ inv
Xs5_34
+ vdd
+ vss
+ stage4[34]
+ stage5[34]
+ inv
Xff_34
+ b
+ stage5[34]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[34]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_35_0
+ vdd
+ vss
+ stage3[17]
+ stage4[35]
+ inv
Xs4_35_1
+ vdd
+ vss
+ stage3[18]
+ stage4[35]
+ inv
Xs5_35
+ vdd
+ vss
+ stage4[35]
+ stage5[35]
+ inv
Xff_35
+ b
+ stage5[35]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[35]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_36_0
+ vdd
+ vss
+ stage3[18]
+ stage4[36]
+ inv
Xs4_36_1
+ vdd
+ vss
+ stage3[18]
+ stage4[36]
+ inv
Xs5_36
+ vdd
+ vss
+ stage4[36]
+ stage5[36]
+ inv
Xff_36
+ b
+ stage5[36]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[36]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_37_0
+ vdd
+ vss
+ stage3[18]
+ stage4[37]
+ inv
Xs4_37_1
+ vdd
+ vss
+ stage3[19]
+ stage4[37]
+ inv
Xs5_37
+ vdd
+ vss
+ stage4[37]
+ stage5[37]
+ inv
Xff_37
+ b
+ stage5[37]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[37]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_38_0
+ vdd
+ vss
+ stage3[19]
+ stage4[38]
+ inv
Xs4_38_1
+ vdd
+ vss
+ stage3[19]
+ stage4[38]
+ inv
Xs5_38
+ vdd
+ vss
+ stage4[38]
+ stage5[38]
+ inv
Xff_38
+ b
+ stage5[38]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[38]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_39_0
+ vdd
+ vss
+ stage3[19]
+ stage4[39]
+ inv
Xs4_39_1
+ vdd
+ vss
+ stage3[20]
+ stage4[39]
+ inv
Xs5_39
+ vdd
+ vss
+ stage4[39]
+ stage5[39]
+ inv
Xff_39
+ b
+ stage5[39]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[39]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_40_0
+ vdd
+ vss
+ stage3[20]
+ stage4[40]
+ inv
Xs4_40_1
+ vdd
+ vss
+ stage3[20]
+ stage4[40]
+ inv
Xs5_40
+ vdd
+ vss
+ stage4[40]
+ stage5[40]
+ inv
Xff_40
+ b
+ stage5[40]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[40]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_41_0
+ vdd
+ vss
+ stage3[20]
+ stage4[41]
+ inv
Xs4_41_1
+ vdd
+ vss
+ stage3[21]
+ stage4[41]
+ inv
Xs5_41
+ vdd
+ vss
+ stage4[41]
+ stage5[41]
+ inv
Xff_41
+ b
+ stage5[41]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[41]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_42_0
+ vdd
+ vss
+ stage3[21]
+ stage4[42]
+ inv
Xs4_42_1
+ vdd
+ vss
+ stage3[21]
+ stage4[42]
+ inv
Xs5_42
+ vdd
+ vss
+ stage4[42]
+ stage5[42]
+ inv
Xff_42
+ b
+ stage5[42]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[42]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_43_0
+ vdd
+ vss
+ stage3[21]
+ stage4[43]
+ inv
Xs4_43_1
+ vdd
+ vss
+ stage3[22]
+ stage4[43]
+ inv
Xs5_43
+ vdd
+ vss
+ stage4[43]
+ stage5[43]
+ inv
Xff_43
+ b
+ stage5[43]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[43]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_44_0
+ vdd
+ vss
+ stage3[22]
+ stage4[44]
+ inv
Xs4_44_1
+ vdd
+ vss
+ stage3[22]
+ stage4[44]
+ inv
Xs5_44
+ vdd
+ vss
+ stage4[44]
+ stage5[44]
+ inv
Xff_44
+ b
+ stage5[44]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[44]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_45_0
+ vdd
+ vss
+ stage3[22]
+ stage4[45]
+ inv
Xs4_45_1
+ vdd
+ vss
+ stage3[23]
+ stage4[45]
+ inv
Xs5_45
+ vdd
+ vss
+ stage4[45]
+ stage5[45]
+ inv
Xff_45
+ b
+ stage5[45]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[45]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_46_0
+ vdd
+ vss
+ stage3[23]
+ stage4[46]
+ inv
Xs4_46_1
+ vdd
+ vss
+ stage3[23]
+ stage4[46]
+ inv
Xs5_46
+ vdd
+ vss
+ stage4[46]
+ stage5[46]
+ inv
Xff_46
+ b
+ stage5[46]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[46]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_47_0
+ vdd
+ vss
+ stage3[23]
+ stage4[47]
+ inv
Xs4_47_1
+ vdd
+ vss
+ stage3[24]
+ stage4[47]
+ inv
Xs5_47
+ vdd
+ vss
+ stage4[47]
+ stage5[47]
+ inv
Xff_47
+ b
+ stage5[47]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[47]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_48_0
+ vdd
+ vss
+ stage3[24]
+ stage4[48]
+ inv
Xs4_48_1
+ vdd
+ vss
+ stage3[24]
+ stage4[48]
+ inv
Xs5_48
+ vdd
+ vss
+ stage4[48]
+ stage5[48]
+ inv
Xff_48
+ b
+ stage5[48]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[48]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_49_0
+ vdd
+ vss
+ stage3[24]
+ stage4[49]
+ inv
Xs4_49_1
+ vdd
+ vss
+ stage3[25]
+ stage4[49]
+ inv
Xs5_49
+ vdd
+ vss
+ stage4[49]
+ stage5[49]
+ inv
Xff_49
+ b
+ stage5[49]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[49]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_50_0
+ vdd
+ vss
+ stage3[25]
+ stage4[50]
+ inv
Xs4_50_1
+ vdd
+ vss
+ stage3[25]
+ stage4[50]
+ inv
Xs5_50
+ vdd
+ vss
+ stage4[50]
+ stage5[50]
+ inv
Xff_50
+ b
+ stage5[50]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[50]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_51_0
+ vdd
+ vss
+ stage3[25]
+ stage4[51]
+ inv
Xs4_51_1
+ vdd
+ vss
+ stage3[26]
+ stage4[51]
+ inv
Xs5_51
+ vdd
+ vss
+ stage4[51]
+ stage5[51]
+ inv
Xff_51
+ b
+ stage5[51]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[51]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_52_0
+ vdd
+ vss
+ stage3[26]
+ stage4[52]
+ inv
Xs4_52_1
+ vdd
+ vss
+ stage3[26]
+ stage4[52]
+ inv
Xs5_52
+ vdd
+ vss
+ stage4[52]
+ stage5[52]
+ inv
Xff_52
+ b
+ stage5[52]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[52]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_53_0
+ vdd
+ vss
+ stage3[26]
+ stage4[53]
+ inv
Xs4_53_1
+ vdd
+ vss
+ stage3[27]
+ stage4[53]
+ inv
Xs5_53
+ vdd
+ vss
+ stage4[53]
+ stage5[53]
+ inv
Xff_53
+ b
+ stage5[53]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[53]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_54_0
+ vdd
+ vss
+ stage3[27]
+ stage4[54]
+ inv
Xs4_54_1
+ vdd
+ vss
+ stage3[27]
+ stage4[54]
+ inv
Xs5_54
+ vdd
+ vss
+ stage4[54]
+ stage5[54]
+ inv
Xff_54
+ b
+ stage5[54]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[54]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_55_0
+ vdd
+ vss
+ stage3[27]
+ stage4[55]
+ inv
Xs4_55_1
+ vdd
+ vss
+ stage3[28]
+ stage4[55]
+ inv
Xs5_55
+ vdd
+ vss
+ stage4[55]
+ stage5[55]
+ inv
Xff_55
+ b
+ stage5[55]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[55]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_56_0
+ vdd
+ vss
+ stage3[28]
+ stage4[56]
+ inv
Xs4_56_1
+ vdd
+ vss
+ stage3[28]
+ stage4[56]
+ inv
Xs5_56
+ vdd
+ vss
+ stage4[56]
+ stage5[56]
+ inv
Xff_56
+ b
+ stage5[56]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[56]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_57_0
+ vdd
+ vss
+ stage3[28]
+ stage4[57]
+ inv
Xs4_57_1
+ vdd
+ vss
+ stage3[29]
+ stage4[57]
+ inv
Xs5_57
+ vdd
+ vss
+ stage4[57]
+ stage5[57]
+ inv
Xff_57
+ b
+ stage5[57]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[57]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_58_0
+ vdd
+ vss
+ stage3[29]
+ stage4[58]
+ inv
Xs4_58_1
+ vdd
+ vss
+ stage3[29]
+ stage4[58]
+ inv
Xs5_58
+ vdd
+ vss
+ stage4[58]
+ stage5[58]
+ inv
Xff_58
+ b
+ stage5[58]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[58]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_59_0
+ vdd
+ vss
+ stage3[29]
+ stage4[59]
+ inv
Xs4_59_1
+ vdd
+ vss
+ stage3[30]
+ stage4[59]
+ inv
Xs5_59
+ vdd
+ vss
+ stage4[59]
+ stage5[59]
+ inv
Xff_59
+ b
+ stage5[59]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[59]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_60_0
+ vdd
+ vss
+ stage3[30]
+ stage4[60]
+ inv
Xs4_60_1
+ vdd
+ vss
+ stage3[30]
+ stage4[60]
+ inv
Xs5_60
+ vdd
+ vss
+ stage4[60]
+ stage5[60]
+ inv
Xff_60
+ b
+ stage5[60]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[60]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_61_0
+ vdd
+ vss
+ stage3[30]
+ stage4[61]
+ inv
Xs4_61_1
+ vdd
+ vss
+ stage3[31]
+ stage4[61]
+ inv
Xs5_61
+ vdd
+ vss
+ stage4[61]
+ stage5[61]
+ inv
Xff_61
+ b
+ stage5[61]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[61]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_62_0
+ vdd
+ vss
+ stage3[31]
+ stage4[62]
+ inv
Xs4_62_1
+ vdd
+ vss
+ stage3[31]
+ stage4[62]
+ inv
Xs5_62
+ vdd
+ vss
+ stage4[62]
+ stage5[62]
+ inv
Xff_62
+ b
+ stage5[62]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[62]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_63_0
+ vdd
+ vss
+ stage3[31]
+ stage4[63]
+ inv
Xs4_63_1
+ vdd
+ vss
+ stage3[32]
+ stage4[63]
+ inv
Xs5_63
+ vdd
+ vss
+ stage4[63]
+ stage5[63]
+ inv
Xff_63
+ b
+ stage5[63]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[63]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_64_0
+ vdd
+ vss
+ stage3[32]
+ stage4[64]
+ inv
Xs4_64_1
+ vdd
+ vss
+ stage3[32]
+ stage4[64]
+ inv
Xs5_64
+ vdd
+ vss
+ stage4[64]
+ stage5[64]
+ inv
Xff_64
+ b
+ stage5[64]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[64]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_65_0
+ vdd
+ vss
+ stage3[32]
+ stage4[65]
+ inv
Xs4_65_1
+ vdd
+ vss
+ stage3[33]
+ stage4[65]
+ inv
Xs5_65
+ vdd
+ vss
+ stage4[65]
+ stage5[65]
+ inv
Xff_65
+ b
+ stage5[65]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[65]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_66_0
+ vdd
+ vss
+ stage3[33]
+ stage4[66]
+ inv
Xs4_66_1
+ vdd
+ vss
+ stage3[33]
+ stage4[66]
+ inv
Xs5_66
+ vdd
+ vss
+ stage4[66]
+ stage5[66]
+ inv
Xff_66
+ b
+ stage5[66]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[66]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_67_0
+ vdd
+ vss
+ stage3[33]
+ stage4[67]
+ inv
Xs4_67_1
+ vdd
+ vss
+ stage3[34]
+ stage4[67]
+ inv
Xs5_67
+ vdd
+ vss
+ stage4[67]
+ stage5[67]
+ inv
Xff_67
+ b
+ stage5[67]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[67]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_68_0
+ vdd
+ vss
+ stage3[34]
+ stage4[68]
+ inv
Xs4_68_1
+ vdd
+ vss
+ stage3[34]
+ stage4[68]
+ inv
Xs5_68
+ vdd
+ vss
+ stage4[68]
+ stage5[68]
+ inv
Xff_68
+ b
+ stage5[68]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[68]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_69_0
+ vdd
+ vss
+ stage3[34]
+ stage4[69]
+ inv
Xs4_69_1
+ vdd
+ vss
+ stage3[35]
+ stage4[69]
+ inv
Xs5_69
+ vdd
+ vss
+ stage4[69]
+ stage5[69]
+ inv
Xff_69
+ b
+ stage5[69]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[69]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_70_0
+ vdd
+ vss
+ stage3[35]
+ stage4[70]
+ inv
Xs4_70_1
+ vdd
+ vss
+ stage3[35]
+ stage4[70]
+ inv
Xs5_70
+ vdd
+ vss
+ stage4[70]
+ stage5[70]
+ inv
Xff_70
+ b
+ stage5[70]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[70]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_71_0
+ vdd
+ vss
+ stage3[35]
+ stage4[71]
+ inv
Xs4_71_1
+ vdd
+ vss
+ stage3[36]
+ stage4[71]
+ inv
Xs5_71
+ vdd
+ vss
+ stage4[71]
+ stage5[71]
+ inv
Xff_71
+ b
+ stage5[71]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[71]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_72_0
+ vdd
+ vss
+ stage3[36]
+ stage4[72]
+ inv
Xs4_72_1
+ vdd
+ vss
+ stage3[36]
+ stage4[72]
+ inv
Xs5_72
+ vdd
+ vss
+ stage4[72]
+ stage5[72]
+ inv
Xff_72
+ b
+ stage5[72]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[72]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_73_0
+ vdd
+ vss
+ stage3[36]
+ stage4[73]
+ inv
Xs4_73_1
+ vdd
+ vss
+ stage3[37]
+ stage4[73]
+ inv
Xs5_73
+ vdd
+ vss
+ stage4[73]
+ stage5[73]
+ inv
Xff_73
+ b
+ stage5[73]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[73]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_74_0
+ vdd
+ vss
+ stage3[37]
+ stage4[74]
+ inv
Xs4_74_1
+ vdd
+ vss
+ stage3[37]
+ stage4[74]
+ inv
Xs5_74
+ vdd
+ vss
+ stage4[74]
+ stage5[74]
+ inv
Xff_74
+ b
+ stage5[74]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[74]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_75_0
+ vdd
+ vss
+ stage3[37]
+ stage4[75]
+ inv
Xs4_75_1
+ vdd
+ vss
+ stage3[38]
+ stage4[75]
+ inv
Xs5_75
+ vdd
+ vss
+ stage4[75]
+ stage5[75]
+ inv
Xff_75
+ b
+ stage5[75]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[75]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_76_0
+ vdd
+ vss
+ stage3[38]
+ stage4[76]
+ inv
Xs4_76_1
+ vdd
+ vss
+ stage3[38]
+ stage4[76]
+ inv
Xs5_76
+ vdd
+ vss
+ stage4[76]
+ stage5[76]
+ inv
Xff_76
+ b
+ stage5[76]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[76]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_77_0
+ vdd
+ vss
+ stage3[38]
+ stage4[77]
+ inv
Xs4_77_1
+ vdd
+ vss
+ stage3[39]
+ stage4[77]
+ inv
Xs5_77
+ vdd
+ vss
+ stage4[77]
+ stage5[77]
+ inv
Xff_77
+ b
+ stage5[77]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[77]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_78_0
+ vdd
+ vss
+ stage3[39]
+ stage4[78]
+ inv
Xs4_78_1
+ vdd
+ vss
+ stage3[39]
+ stage4[78]
+ inv
Xs5_78
+ vdd
+ vss
+ stage4[78]
+ stage5[78]
+ inv
Xff_78
+ b
+ stage5[78]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[78]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_79_0
+ vdd
+ vss
+ stage3[39]
+ stage4[79]
+ inv
Xs4_79_1
+ vdd
+ vss
+ stage3[40]
+ stage4[79]
+ inv
Xs5_79
+ vdd
+ vss
+ stage4[79]
+ stage5[79]
+ inv
Xff_79
+ b
+ stage5[79]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[79]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_80_0
+ vdd
+ vss
+ stage3[40]
+ stage4[80]
+ inv
Xs4_80_1
+ vdd
+ vss
+ stage3[40]
+ stage4[80]
+ inv
Xs5_80
+ vdd
+ vss
+ stage4[80]
+ stage5[80]
+ inv
Xff_80
+ b
+ stage5[80]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[80]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_81_0
+ vdd
+ vss
+ stage3[40]
+ stage4[81]
+ inv
Xs4_81_1
+ vdd
+ vss
+ stage3[41]
+ stage4[81]
+ inv
Xs5_81
+ vdd
+ vss
+ stage4[81]
+ stage5[81]
+ inv
Xff_81
+ b
+ stage5[81]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[81]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_82_0
+ vdd
+ vss
+ stage3[41]
+ stage4[82]
+ inv
Xs4_82_1
+ vdd
+ vss
+ stage3[41]
+ stage4[82]
+ inv
Xs5_82
+ vdd
+ vss
+ stage4[82]
+ stage5[82]
+ inv
Xff_82
+ b
+ stage5[82]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[82]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_83_0
+ vdd
+ vss
+ stage3[41]
+ stage4[83]
+ inv
Xs4_83_1
+ vdd
+ vss
+ stage3[42]
+ stage4[83]
+ inv
Xs5_83
+ vdd
+ vss
+ stage4[83]
+ stage5[83]
+ inv
Xff_83
+ b
+ stage5[83]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[83]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_84_0
+ vdd
+ vss
+ stage3[42]
+ stage4[84]
+ inv
Xs4_84_1
+ vdd
+ vss
+ stage3[42]
+ stage4[84]
+ inv
Xs5_84
+ vdd
+ vss
+ stage4[84]
+ stage5[84]
+ inv
Xff_84
+ b
+ stage5[84]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[84]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_85_0
+ vdd
+ vss
+ stage3[42]
+ stage4[85]
+ inv
Xs4_85_1
+ vdd
+ vss
+ stage3[43]
+ stage4[85]
+ inv
Xs5_85
+ vdd
+ vss
+ stage4[85]
+ stage5[85]
+ inv
Xff_85
+ b
+ stage5[85]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[85]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_86_0
+ vdd
+ vss
+ stage3[43]
+ stage4[86]
+ inv
Xs4_86_1
+ vdd
+ vss
+ stage3[43]
+ stage4[86]
+ inv
Xs5_86
+ vdd
+ vss
+ stage4[86]
+ stage5[86]
+ inv
Xff_86
+ b
+ stage5[86]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[86]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_87_0
+ vdd
+ vss
+ stage3[43]
+ stage4[87]
+ inv
Xs4_87_1
+ vdd
+ vss
+ stage3[44]
+ stage4[87]
+ inv
Xs5_87
+ vdd
+ vss
+ stage4[87]
+ stage5[87]
+ inv
Xff_87
+ b
+ stage5[87]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[87]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_88_0
+ vdd
+ vss
+ stage3[44]
+ stage4[88]
+ inv
Xs4_88_1
+ vdd
+ vss
+ stage3[44]
+ stage4[88]
+ inv
Xs5_88
+ vdd
+ vss
+ stage4[88]
+ stage5[88]
+ inv
Xff_88
+ b
+ stage5[88]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[88]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_89_0
+ vdd
+ vss
+ stage3[44]
+ stage4[89]
+ inv
Xs4_89_1
+ vdd
+ vss
+ stage3[45]
+ stage4[89]
+ inv
Xs5_89
+ vdd
+ vss
+ stage4[89]
+ stage5[89]
+ inv
Xff_89
+ b
+ stage5[89]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[89]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_90_0
+ vdd
+ vss
+ stage3[45]
+ stage4[90]
+ inv
Xs4_90_1
+ vdd
+ vss
+ stage3[45]
+ stage4[90]
+ inv
Xs5_90
+ vdd
+ vss
+ stage4[90]
+ stage5[90]
+ inv
Xff_90
+ b
+ stage5[90]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[90]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_91_0
+ vdd
+ vss
+ stage3[45]
+ stage4[91]
+ inv
Xs4_91_1
+ vdd
+ vss
+ stage3[46]
+ stage4[91]
+ inv
Xs5_91
+ vdd
+ vss
+ stage4[91]
+ stage5[91]
+ inv
Xff_91
+ b
+ stage5[91]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[91]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_92_0
+ vdd
+ vss
+ stage3[46]
+ stage4[92]
+ inv
Xs4_92_1
+ vdd
+ vss
+ stage3[46]
+ stage4[92]
+ inv
Xs5_92
+ vdd
+ vss
+ stage4[92]
+ stage5[92]
+ inv
Xff_92
+ b
+ stage5[92]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[92]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_93_0
+ vdd
+ vss
+ stage3[46]
+ stage4[93]
+ inv
Xs4_93_1
+ vdd
+ vss
+ stage3[47]
+ stage4[93]
+ inv
Xs5_93
+ vdd
+ vss
+ stage4[93]
+ stage5[93]
+ inv
Xff_93
+ b
+ stage5[93]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[93]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_94_0
+ vdd
+ vss
+ stage3[47]
+ stage4[94]
+ inv
Xs4_94_1
+ vdd
+ vss
+ stage3[47]
+ stage4[94]
+ inv
Xs5_94
+ vdd
+ vss
+ stage4[94]
+ stage5[94]
+ inv
Xff_94
+ b
+ stage5[94]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[94]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_95_0
+ vdd
+ vss
+ stage3[47]
+ stage4[95]
+ inv
Xs4_95_1
+ vdd
+ vss
+ stage3[48]
+ stage4[95]
+ inv
Xs5_95
+ vdd
+ vss
+ stage4[95]
+ stage5[95]
+ inv
Xff_95
+ b
+ stage5[95]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[95]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_96_0
+ vdd
+ vss
+ stage3[48]
+ stage4[96]
+ inv
Xs4_96_1
+ vdd
+ vss
+ stage3[48]
+ stage4[96]
+ inv
Xs5_96
+ vdd
+ vss
+ stage4[96]
+ stage5[96]
+ inv
Xff_96
+ b
+ stage5[96]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[96]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_97_0
+ vdd
+ vss
+ stage3[48]
+ stage4[97]
+ inv
Xs4_97_1
+ vdd
+ vss
+ stage3[49]
+ stage4[97]
+ inv
Xs5_97
+ vdd
+ vss
+ stage4[97]
+ stage5[97]
+ inv
Xff_97
+ b
+ stage5[97]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[97]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_98_0
+ vdd
+ vss
+ stage3[49]
+ stage4[98]
+ inv
Xs4_98_1
+ vdd
+ vss
+ stage3[49]
+ stage4[98]
+ inv
Xs5_98
+ vdd
+ vss
+ stage4[98]
+ stage5[98]
+ inv
Xff_98
+ b
+ stage5[98]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[98]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_99_0
+ vdd
+ vss
+ stage3[49]
+ stage4[99]
+ inv
Xs4_99_1
+ vdd
+ vss
+ stage3[50]
+ stage4[99]
+ inv
Xs5_99
+ vdd
+ vss
+ stage4[99]
+ stage5[99]
+ inv
Xff_99
+ b
+ stage5[99]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[99]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_100_0
+ vdd
+ vss
+ stage3[50]
+ stage4[100]
+ inv
Xs4_100_1
+ vdd
+ vss
+ stage3[50]
+ stage4[100]
+ inv
Xs5_100
+ vdd
+ vss
+ stage4[100]
+ stage5[100]
+ inv
Xff_100
+ b
+ stage5[100]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[100]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_101_0
+ vdd
+ vss
+ stage3[50]
+ stage4[101]
+ inv
Xs4_101_1
+ vdd
+ vss
+ stage3[51]
+ stage4[101]
+ inv
Xs5_101
+ vdd
+ vss
+ stage4[101]
+ stage5[101]
+ inv
Xff_101
+ b
+ stage5[101]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[101]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_102_0
+ vdd
+ vss
+ stage3[51]
+ stage4[102]
+ inv
Xs4_102_1
+ vdd
+ vss
+ stage3[51]
+ stage4[102]
+ inv
Xs5_102
+ vdd
+ vss
+ stage4[102]
+ stage5[102]
+ inv
Xff_102
+ b
+ stage5[102]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[102]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_103_0
+ vdd
+ vss
+ stage3[51]
+ stage4[103]
+ inv
Xs4_103_1
+ vdd
+ vss
+ stage3[52]
+ stage4[103]
+ inv
Xs5_103
+ vdd
+ vss
+ stage4[103]
+ stage5[103]
+ inv
Xff_103
+ b
+ stage5[103]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[103]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_104_0
+ vdd
+ vss
+ stage3[52]
+ stage4[104]
+ inv
Xs4_104_1
+ vdd
+ vss
+ stage3[52]
+ stage4[104]
+ inv
Xs5_104
+ vdd
+ vss
+ stage4[104]
+ stage5[104]
+ inv
Xff_104
+ b
+ stage5[104]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[104]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_105_0
+ vdd
+ vss
+ stage3[52]
+ stage4[105]
+ inv
Xs4_105_1
+ vdd
+ vss
+ stage3[53]
+ stage4[105]
+ inv
Xs5_105
+ vdd
+ vss
+ stage4[105]
+ stage5[105]
+ inv
Xff_105
+ b
+ stage5[105]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[105]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_106_0
+ vdd
+ vss
+ stage3[53]
+ stage4[106]
+ inv
Xs4_106_1
+ vdd
+ vss
+ stage3[53]
+ stage4[106]
+ inv
Xs5_106
+ vdd
+ vss
+ stage4[106]
+ stage5[106]
+ inv
Xff_106
+ b
+ stage5[106]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[106]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_107_0
+ vdd
+ vss
+ stage3[53]
+ stage4[107]
+ inv
Xs4_107_1
+ vdd
+ vss
+ stage3[54]
+ stage4[107]
+ inv
Xs5_107
+ vdd
+ vss
+ stage4[107]
+ stage5[107]
+ inv
Xff_107
+ b
+ stage5[107]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[107]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_108_0
+ vdd
+ vss
+ stage3[54]
+ stage4[108]
+ inv
Xs4_108_1
+ vdd
+ vss
+ stage3[54]
+ stage4[108]
+ inv
Xs5_108
+ vdd
+ vss
+ stage4[108]
+ stage5[108]
+ inv
Xff_108
+ b
+ stage5[108]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[108]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_109_0
+ vdd
+ vss
+ stage3[54]
+ stage4[109]
+ inv
Xs4_109_1
+ vdd
+ vss
+ stage3[55]
+ stage4[109]
+ inv
Xs5_109
+ vdd
+ vss
+ stage4[109]
+ stage5[109]
+ inv
Xff_109
+ b
+ stage5[109]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[109]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_110_0
+ vdd
+ vss
+ stage3[55]
+ stage4[110]
+ inv
Xs4_110_1
+ vdd
+ vss
+ stage3[55]
+ stage4[110]
+ inv
Xs5_110
+ vdd
+ vss
+ stage4[110]
+ stage5[110]
+ inv
Xff_110
+ b
+ stage5[110]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[110]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_111_0
+ vdd
+ vss
+ stage3[55]
+ stage4[111]
+ inv
Xs4_111_1
+ vdd
+ vss
+ stage3[56]
+ stage4[111]
+ inv
Xs5_111
+ vdd
+ vss
+ stage4[111]
+ stage5[111]
+ inv
Xff_111
+ b
+ stage5[111]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[111]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_112_0
+ vdd
+ vss
+ stage3[56]
+ stage4[112]
+ inv
Xs4_112_1
+ vdd
+ vss
+ stage3[56]
+ stage4[112]
+ inv
Xs5_112
+ vdd
+ vss
+ stage4[112]
+ stage5[112]
+ inv
Xff_112
+ b
+ stage5[112]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[112]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_113_0
+ vdd
+ vss
+ stage3[56]
+ stage4[113]
+ inv
Xs4_113_1
+ vdd
+ vss
+ stage3[57]
+ stage4[113]
+ inv
Xs5_113
+ vdd
+ vss
+ stage4[113]
+ stage5[113]
+ inv
Xff_113
+ b
+ stage5[113]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[113]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_114_0
+ vdd
+ vss
+ stage3[57]
+ stage4[114]
+ inv
Xs4_114_1
+ vdd
+ vss
+ stage3[57]
+ stage4[114]
+ inv
Xs5_114
+ vdd
+ vss
+ stage4[114]
+ stage5[114]
+ inv
Xff_114
+ b
+ stage5[114]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[114]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_115_0
+ vdd
+ vss
+ stage3[57]
+ stage4[115]
+ inv
Xs4_115_1
+ vdd
+ vss
+ stage3[58]
+ stage4[115]
+ inv
Xs5_115
+ vdd
+ vss
+ stage4[115]
+ stage5[115]
+ inv
Xff_115
+ b
+ stage5[115]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[115]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_116_0
+ vdd
+ vss
+ stage3[58]
+ stage4[116]
+ inv
Xs4_116_1
+ vdd
+ vss
+ stage3[58]
+ stage4[116]
+ inv
Xs5_116
+ vdd
+ vss
+ stage4[116]
+ stage5[116]
+ inv
Xff_116
+ b
+ stage5[116]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[116]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_117_0
+ vdd
+ vss
+ stage3[58]
+ stage4[117]
+ inv
Xs4_117_1
+ vdd
+ vss
+ stage3[59]
+ stage4[117]
+ inv
Xs5_117
+ vdd
+ vss
+ stage4[117]
+ stage5[117]
+ inv
Xff_117
+ b
+ stage5[117]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[117]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_118_0
+ vdd
+ vss
+ stage3[59]
+ stage4[118]
+ inv
Xs4_118_1
+ vdd
+ vss
+ stage3[59]
+ stage4[118]
+ inv
Xs5_118
+ vdd
+ vss
+ stage4[118]
+ stage5[118]
+ inv
Xff_118
+ b
+ stage5[118]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[118]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_119_0
+ vdd
+ vss
+ stage3[59]
+ stage4[119]
+ inv
Xs4_119_1
+ vdd
+ vss
+ stage3[60]
+ stage4[119]
+ inv
Xs5_119
+ vdd
+ vss
+ stage4[119]
+ stage5[119]
+ inv
Xff_119
+ b
+ stage5[119]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[119]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_120_0
+ vdd
+ vss
+ stage3[60]
+ stage4[120]
+ inv
Xs4_120_1
+ vdd
+ vss
+ stage3[60]
+ stage4[120]
+ inv
Xs5_120
+ vdd
+ vss
+ stage4[120]
+ stage5[120]
+ inv
Xff_120
+ b
+ stage5[120]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[120]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_121_0
+ vdd
+ vss
+ stage3[60]
+ stage4[121]
+ inv
Xs4_121_1
+ vdd
+ vss
+ stage3[61]
+ stage4[121]
+ inv
Xs5_121
+ vdd
+ vss
+ stage4[121]
+ stage5[121]
+ inv
Xff_121
+ b
+ stage5[121]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[121]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_122_0
+ vdd
+ vss
+ stage3[61]
+ stage4[122]
+ inv
Xs4_122_1
+ vdd
+ vss
+ stage3[61]
+ stage4[122]
+ inv
Xs5_122
+ vdd
+ vss
+ stage4[122]
+ stage5[122]
+ inv
Xff_122
+ b
+ stage5[122]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[122]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_123_0
+ vdd
+ vss
+ stage3[61]
+ stage4[123]
+ inv
Xs4_123_1
+ vdd
+ vss
+ stage3[62]
+ stage4[123]
+ inv
Xs5_123
+ vdd
+ vss
+ stage4[123]
+ stage5[123]
+ inv
Xff_123
+ b
+ stage5[123]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[123]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_124_0
+ vdd
+ vss
+ stage3[62]
+ stage4[124]
+ inv
Xs4_124_1
+ vdd
+ vss
+ stage3[62]
+ stage4[124]
+ inv
Xs5_124
+ vdd
+ vss
+ stage4[124]
+ stage5[124]
+ inv
Xff_124
+ b
+ stage5[124]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[124]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_125_0
+ vdd
+ vss
+ stage3[62]
+ stage4[125]
+ inv
Xs4_125_1
+ vdd
+ vss
+ stage3[63]
+ stage4[125]
+ inv
Xs5_125
+ vdd
+ vss
+ stage4[125]
+ stage5[125]
+ inv
Xff_125
+ b
+ stage5[125]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[125]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_126_0
+ vdd
+ vss
+ stage3[63]
+ stage4[126]
+ inv
Xs4_126_1
+ vdd
+ vss
+ stage3[63]
+ stage4[126]
+ inv
Xs5_126
+ vdd
+ vss
+ stage4[126]
+ stage5[126]
+ inv
Xff_126
+ b
+ stage5[126]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[126]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_127_0
+ vdd
+ vss
+ stage3[63]
+ stage4[127]
+ inv
Xs4_127_1
+ vdd
+ vss
+ stage3[64]
+ stage4[127]
+ inv
Xs5_127
+ vdd
+ vss
+ stage4[127]
+ stage5[127]
+ inv
Xff_127
+ b
+ stage5[127]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[127]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_128_0
+ vdd
+ vss
+ stage3[64]
+ stage4[128]
+ inv
Xs4_128_1
+ vdd
+ vss
+ stage3[64]
+ stage4[128]
+ inv
Xs5_128
+ vdd
+ vss
+ stage4[128]
+ stage5[128]
+ inv
Xff_128
+ b
+ stage5[128]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[128]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_129_0
+ vdd
+ vss
+ stage3[64]
+ stage4[129]
+ inv
Xs4_129_1
+ vdd
+ vss
+ stage3[65]
+ stage4[129]
+ inv
Xs5_129
+ vdd
+ vss
+ stage4[129]
+ stage5[129]
+ inv
Xff_129
+ b
+ stage5[129]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[129]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_130_0
+ vdd
+ vss
+ stage3[65]
+ stage4[130]
+ inv
Xs4_130_1
+ vdd
+ vss
+ stage3[65]
+ stage4[130]
+ inv
Xs5_130
+ vdd
+ vss
+ stage4[130]
+ stage5[130]
+ inv
Xff_130
+ b
+ stage5[130]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[130]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_131_0
+ vdd
+ vss
+ stage3[65]
+ stage4[131]
+ inv
Xs4_131_1
+ vdd
+ vss
+ stage3[66]
+ stage4[131]
+ inv
Xs5_131
+ vdd
+ vss
+ stage4[131]
+ stage5[131]
+ inv
Xff_131
+ b
+ stage5[131]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[131]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_132_0
+ vdd
+ vss
+ stage3[66]
+ stage4[132]
+ inv
Xs4_132_1
+ vdd
+ vss
+ stage3[66]
+ stage4[132]
+ inv
Xs5_132
+ vdd
+ vss
+ stage4[132]
+ stage5[132]
+ inv
Xff_132
+ b
+ stage5[132]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[132]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_133_0
+ vdd
+ vss
+ stage3[66]
+ stage4[133]
+ inv
Xs4_133_1
+ vdd
+ vss
+ stage3[67]
+ stage4[133]
+ inv
Xs5_133
+ vdd
+ vss
+ stage4[133]
+ stage5[133]
+ inv
Xff_133
+ b
+ stage5[133]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[133]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_134_0
+ vdd
+ vss
+ stage3[67]
+ stage4[134]
+ inv
Xs4_134_1
+ vdd
+ vss
+ stage3[67]
+ stage4[134]
+ inv
Xs5_134
+ vdd
+ vss
+ stage4[134]
+ stage5[134]
+ inv
Xff_134
+ b
+ stage5[134]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[134]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_135_0
+ vdd
+ vss
+ stage3[67]
+ stage4[135]
+ inv
Xs4_135_1
+ vdd
+ vss
+ stage3[68]
+ stage4[135]
+ inv
Xs5_135
+ vdd
+ vss
+ stage4[135]
+ stage5[135]
+ inv
Xff_135
+ b
+ stage5[135]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[135]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_136_0
+ vdd
+ vss
+ stage3[68]
+ stage4[136]
+ inv
Xs4_136_1
+ vdd
+ vss
+ stage3[68]
+ stage4[136]
+ inv
Xs5_136
+ vdd
+ vss
+ stage4[136]
+ stage5[136]
+ inv
Xff_136
+ b
+ stage5[136]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[136]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_137_0
+ vdd
+ vss
+ stage3[68]
+ stage4[137]
+ inv
Xs4_137_1
+ vdd
+ vss
+ stage3[69]
+ stage4[137]
+ inv
Xs5_137
+ vdd
+ vss
+ stage4[137]
+ stage5[137]
+ inv
Xff_137
+ b
+ stage5[137]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[137]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_138_0
+ vdd
+ vss
+ stage3[69]
+ stage4[138]
+ inv
Xs4_138_1
+ vdd
+ vss
+ stage3[69]
+ stage4[138]
+ inv
Xs5_138
+ vdd
+ vss
+ stage4[138]
+ stage5[138]
+ inv
Xff_138
+ b
+ stage5[138]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[138]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_139_0
+ vdd
+ vss
+ stage3[69]
+ stage4[139]
+ inv
Xs4_139_1
+ vdd
+ vss
+ stage3[70]
+ stage4[139]
+ inv
Xs5_139
+ vdd
+ vss
+ stage4[139]
+ stage5[139]
+ inv
Xff_139
+ b
+ stage5[139]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[139]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_140_0
+ vdd
+ vss
+ stage3[70]
+ stage4[140]
+ inv
Xs4_140_1
+ vdd
+ vss
+ stage3[70]
+ stage4[140]
+ inv
Xs5_140
+ vdd
+ vss
+ stage4[140]
+ stage5[140]
+ inv
Xff_140
+ b
+ stage5[140]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[140]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_141_0
+ vdd
+ vss
+ stage3[70]
+ stage4[141]
+ inv
Xs4_141_1
+ vdd
+ vss
+ stage3[71]
+ stage4[141]
+ inv
Xs5_141
+ vdd
+ vss
+ stage4[141]
+ stage5[141]
+ inv
Xff_141
+ b
+ stage5[141]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[141]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_142_0
+ vdd
+ vss
+ stage3[71]
+ stage4[142]
+ inv
Xs4_142_1
+ vdd
+ vss
+ stage3[71]
+ stage4[142]
+ inv
Xs5_142
+ vdd
+ vss
+ stage4[142]
+ stage5[142]
+ inv
Xff_142
+ b
+ stage5[142]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[142]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_143_0
+ vdd
+ vss
+ stage3[71]
+ stage4[143]
+ inv
Xs4_143_1
+ vdd
+ vss
+ stage3[72]
+ stage4[143]
+ inv
Xs5_143
+ vdd
+ vss
+ stage4[143]
+ stage5[143]
+ inv
Xff_143
+ b
+ stage5[143]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[143]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_144_0
+ vdd
+ vss
+ stage3[72]
+ stage4[144]
+ inv
Xs4_144_1
+ vdd
+ vss
+ stage3[72]
+ stage4[144]
+ inv
Xs5_144
+ vdd
+ vss
+ stage4[144]
+ stage5[144]
+ inv
Xff_144
+ b
+ stage5[144]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[144]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_145_0
+ vdd
+ vss
+ stage3[72]
+ stage4[145]
+ inv
Xs4_145_1
+ vdd
+ vss
+ stage3[73]
+ stage4[145]
+ inv
Xs5_145
+ vdd
+ vss
+ stage4[145]
+ stage5[145]
+ inv
Xff_145
+ b
+ stage5[145]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[145]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_146_0
+ vdd
+ vss
+ stage3[73]
+ stage4[146]
+ inv
Xs4_146_1
+ vdd
+ vss
+ stage3[73]
+ stage4[146]
+ inv
Xs5_146
+ vdd
+ vss
+ stage4[146]
+ stage5[146]
+ inv
Xff_146
+ b
+ stage5[146]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[146]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_147_0
+ vdd
+ vss
+ stage3[73]
+ stage4[147]
+ inv
Xs4_147_1
+ vdd
+ vss
+ stage3[74]
+ stage4[147]
+ inv
Xs5_147
+ vdd
+ vss
+ stage4[147]
+ stage5[147]
+ inv
Xff_147
+ b
+ stage5[147]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[147]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_148_0
+ vdd
+ vss
+ stage3[74]
+ stage4[148]
+ inv
Xs4_148_1
+ vdd
+ vss
+ stage3[74]
+ stage4[148]
+ inv
Xs5_148
+ vdd
+ vss
+ stage4[148]
+ stage5[148]
+ inv
Xff_148
+ b
+ stage5[148]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[148]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_149_0
+ vdd
+ vss
+ stage3[74]
+ stage4[149]
+ inv
Xs4_149_1
+ vdd
+ vss
+ stage3[75]
+ stage4[149]
+ inv
Xs5_149
+ vdd
+ vss
+ stage4[149]
+ stage5[149]
+ inv
Xff_149
+ b
+ stage5[149]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[149]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_150_0
+ vdd
+ vss
+ stage3[75]
+ stage4[150]
+ inv
Xs4_150_1
+ vdd
+ vss
+ stage3[75]
+ stage4[150]
+ inv
Xs5_150
+ vdd
+ vss
+ stage4[150]
+ stage5[150]
+ inv
Xff_150
+ b
+ stage5[150]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[150]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_151_0
+ vdd
+ vss
+ stage3[75]
+ stage4[151]
+ inv
Xs4_151_1
+ vdd
+ vss
+ stage3[76]
+ stage4[151]
+ inv
Xs5_151
+ vdd
+ vss
+ stage4[151]
+ stage5[151]
+ inv
Xff_151
+ b
+ stage5[151]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[151]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_152_0
+ vdd
+ vss
+ stage3[76]
+ stage4[152]
+ inv
Xs4_152_1
+ vdd
+ vss
+ stage3[76]
+ stage4[152]
+ inv
Xs5_152
+ vdd
+ vss
+ stage4[152]
+ stage5[152]
+ inv
Xff_152
+ b
+ stage5[152]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[152]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_153_0
+ vdd
+ vss
+ stage3[76]
+ stage4[153]
+ inv
Xs4_153_1
+ vdd
+ vss
+ stage3[77]
+ stage4[153]
+ inv
Xs5_153
+ vdd
+ vss
+ stage4[153]
+ stage5[153]
+ inv
Xff_153
+ b
+ stage5[153]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[153]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_154_0
+ vdd
+ vss
+ stage3[77]
+ stage4[154]
+ inv
Xs4_154_1
+ vdd
+ vss
+ stage3[77]
+ stage4[154]
+ inv
Xs5_154
+ vdd
+ vss
+ stage4[154]
+ stage5[154]
+ inv
Xff_154
+ b
+ stage5[154]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[154]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_155_0
+ vdd
+ vss
+ stage3[77]
+ stage4[155]
+ inv
Xs4_155_1
+ vdd
+ vss
+ stage3[78]
+ stage4[155]
+ inv
Xs5_155
+ vdd
+ vss
+ stage4[155]
+ stage5[155]
+ inv
Xff_155
+ b
+ stage5[155]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[155]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_156_0
+ vdd
+ vss
+ stage3[78]
+ stage4[156]
+ inv
Xs4_156_1
+ vdd
+ vss
+ stage3[78]
+ stage4[156]
+ inv
Xs5_156
+ vdd
+ vss
+ stage4[156]
+ stage5[156]
+ inv
Xff_156
+ b
+ stage5[156]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[156]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_157_0
+ vdd
+ vss
+ stage3[78]
+ stage4[157]
+ inv
Xs4_157_1
+ vdd
+ vss
+ stage3[79]
+ stage4[157]
+ inv
Xs5_157
+ vdd
+ vss
+ stage4[157]
+ stage5[157]
+ inv
Xff_157
+ b
+ stage5[157]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[157]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_158_0
+ vdd
+ vss
+ stage3[79]
+ stage4[158]
+ inv
Xs4_158_1
+ vdd
+ vss
+ stage3[79]
+ stage4[158]
+ inv
Xs5_158
+ vdd
+ vss
+ stage4[158]
+ stage5[158]
+ inv
Xff_158
+ b
+ stage5[158]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[158]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_159_0
+ vdd
+ vss
+ stage3[79]
+ stage4[159]
+ inv
Xs4_159_1
+ vdd
+ vss
+ stage3[80]
+ stage4[159]
+ inv
Xs5_159
+ vdd
+ vss
+ stage4[159]
+ stage5[159]
+ inv
Xff_159
+ b
+ stage5[159]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[159]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_160_0
+ vdd
+ vss
+ stage3[80]
+ stage4[160]
+ inv
Xs4_160_1
+ vdd
+ vss
+ stage3[80]
+ stage4[160]
+ inv
Xs5_160
+ vdd
+ vss
+ stage4[160]
+ stage5[160]
+ inv
Xff_160
+ b
+ stage5[160]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[160]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_161_0
+ vdd
+ vss
+ stage3[80]
+ stage4[161]
+ inv
Xs4_161_1
+ vdd
+ vss
+ stage3[81]
+ stage4[161]
+ inv
Xs5_161
+ vdd
+ vss
+ stage4[161]
+ stage5[161]
+ inv
Xff_161
+ b
+ stage5[161]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[161]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_162_0
+ vdd
+ vss
+ stage3[81]
+ stage4[162]
+ inv
Xs4_162_1
+ vdd
+ vss
+ stage3[81]
+ stage4[162]
+ inv
Xs5_162
+ vdd
+ vss
+ stage4[162]
+ stage5[162]
+ inv
Xff_162
+ b
+ stage5[162]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[162]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_163_0
+ vdd
+ vss
+ stage3[81]
+ stage4[163]
+ inv
Xs4_163_1
+ vdd
+ vss
+ stage3[82]
+ stage4[163]
+ inv
Xs5_163
+ vdd
+ vss
+ stage4[163]
+ stage5[163]
+ inv
Xff_163
+ b
+ stage5[163]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[163]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_164_0
+ vdd
+ vss
+ stage3[82]
+ stage4[164]
+ inv
Xs4_164_1
+ vdd
+ vss
+ stage3[82]
+ stage4[164]
+ inv
Xs5_164
+ vdd
+ vss
+ stage4[164]
+ stage5[164]
+ inv
Xff_164
+ b
+ stage5[164]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[164]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_165_0
+ vdd
+ vss
+ stage3[82]
+ stage4[165]
+ inv
Xs4_165_1
+ vdd
+ vss
+ stage3[83]
+ stage4[165]
+ inv
Xs5_165
+ vdd
+ vss
+ stage4[165]
+ stage5[165]
+ inv
Xff_165
+ b
+ stage5[165]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[165]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_166_0
+ vdd
+ vss
+ stage3[83]
+ stage4[166]
+ inv
Xs4_166_1
+ vdd
+ vss
+ stage3[83]
+ stage4[166]
+ inv
Xs5_166
+ vdd
+ vss
+ stage4[166]
+ stage5[166]
+ inv
Xff_166
+ b
+ stage5[166]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[166]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_167_0
+ vdd
+ vss
+ stage3[83]
+ stage4[167]
+ inv
Xs4_167_1
+ vdd
+ vss
+ stage3[84]
+ stage4[167]
+ inv
Xs5_167
+ vdd
+ vss
+ stage4[167]
+ stage5[167]
+ inv
Xff_167
+ b
+ stage5[167]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[167]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_168_0
+ vdd
+ vss
+ stage3[84]
+ stage4[168]
+ inv
Xs4_168_1
+ vdd
+ vss
+ stage3[84]
+ stage4[168]
+ inv
Xs5_168
+ vdd
+ vss
+ stage4[168]
+ stage5[168]
+ inv
Xff_168
+ b
+ stage5[168]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[168]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_169_0
+ vdd
+ vss
+ stage3[84]
+ stage4[169]
+ inv
Xs4_169_1
+ vdd
+ vss
+ stage3[85]
+ stage4[169]
+ inv
Xs5_169
+ vdd
+ vss
+ stage4[169]
+ stage5[169]
+ inv
Xff_169
+ b
+ stage5[169]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[169]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_170_0
+ vdd
+ vss
+ stage3[85]
+ stage4[170]
+ inv
Xs4_170_1
+ vdd
+ vss
+ stage3[85]
+ stage4[170]
+ inv
Xs5_170
+ vdd
+ vss
+ stage4[170]
+ stage5[170]
+ inv
Xff_170
+ b
+ stage5[170]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[170]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_171_0
+ vdd
+ vss
+ stage3[85]
+ stage4[171]
+ inv
Xs4_171_1
+ vdd
+ vss
+ stage3[86]
+ stage4[171]
+ inv
Xs5_171
+ vdd
+ vss
+ stage4[171]
+ stage5[171]
+ inv
Xff_171
+ b
+ stage5[171]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[171]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_172_0
+ vdd
+ vss
+ stage3[86]
+ stage4[172]
+ inv
Xs4_172_1
+ vdd
+ vss
+ stage3[86]
+ stage4[172]
+ inv
Xs5_172
+ vdd
+ vss
+ stage4[172]
+ stage5[172]
+ inv
Xff_172
+ b
+ stage5[172]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[172]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_173_0
+ vdd
+ vss
+ stage3[86]
+ stage4[173]
+ inv
Xs4_173_1
+ vdd
+ vss
+ stage3[87]
+ stage4[173]
+ inv
Xs5_173
+ vdd
+ vss
+ stage4[173]
+ stage5[173]
+ inv
Xff_173
+ b
+ stage5[173]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[173]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_174_0
+ vdd
+ vss
+ stage3[87]
+ stage4[174]
+ inv
Xs4_174_1
+ vdd
+ vss
+ stage3[87]
+ stage4[174]
+ inv
Xs5_174
+ vdd
+ vss
+ stage4[174]
+ stage5[174]
+ inv
Xff_174
+ b
+ stage5[174]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[174]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_175_0
+ vdd
+ vss
+ stage3[87]
+ stage4[175]
+ inv
Xs4_175_1
+ vdd
+ vss
+ stage3[88]
+ stage4[175]
+ inv
Xs5_175
+ vdd
+ vss
+ stage4[175]
+ stage5[175]
+ inv
Xff_175
+ b
+ stage5[175]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[175]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_176_0
+ vdd
+ vss
+ stage3[88]
+ stage4[176]
+ inv
Xs4_176_1
+ vdd
+ vss
+ stage3[88]
+ stage4[176]
+ inv
Xs5_176
+ vdd
+ vss
+ stage4[176]
+ stage5[176]
+ inv
Xff_176
+ b
+ stage5[176]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[176]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_177_0
+ vdd
+ vss
+ stage3[88]
+ stage4[177]
+ inv
Xs4_177_1
+ vdd
+ vss
+ stage3[89]
+ stage4[177]
+ inv
Xs5_177
+ vdd
+ vss
+ stage4[177]
+ stage5[177]
+ inv
Xff_177
+ b
+ stage5[177]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[177]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_178_0
+ vdd
+ vss
+ stage3[89]
+ stage4[178]
+ inv
Xs4_178_1
+ vdd
+ vss
+ stage3[89]
+ stage4[178]
+ inv
Xs5_178
+ vdd
+ vss
+ stage4[178]
+ stage5[178]
+ inv
Xff_178
+ b
+ stage5[178]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[178]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_179_0
+ vdd
+ vss
+ stage3[89]
+ stage4[179]
+ inv
Xs4_179_1
+ vdd
+ vss
+ stage3[90]
+ stage4[179]
+ inv
Xs5_179
+ vdd
+ vss
+ stage4[179]
+ stage5[179]
+ inv
Xff_179
+ b
+ stage5[179]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[179]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_180_0
+ vdd
+ vss
+ stage3[90]
+ stage4[180]
+ inv
Xs4_180_1
+ vdd
+ vss
+ stage3[90]
+ stage4[180]
+ inv
Xs5_180
+ vdd
+ vss
+ stage4[180]
+ stage5[180]
+ inv
Xff_180
+ b
+ stage5[180]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[180]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_181_0
+ vdd
+ vss
+ stage3[90]
+ stage4[181]
+ inv
Xs4_181_1
+ vdd
+ vss
+ stage3[91]
+ stage4[181]
+ inv
Xs5_181
+ vdd
+ vss
+ stage4[181]
+ stage5[181]
+ inv
Xff_181
+ b
+ stage5[181]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[181]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_182_0
+ vdd
+ vss
+ stage3[91]
+ stage4[182]
+ inv
Xs4_182_1
+ vdd
+ vss
+ stage3[91]
+ stage4[182]
+ inv
Xs5_182
+ vdd
+ vss
+ stage4[182]
+ stage5[182]
+ inv
Xff_182
+ b
+ stage5[182]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[182]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_183_0
+ vdd
+ vss
+ stage3[91]
+ stage4[183]
+ inv
Xs4_183_1
+ vdd
+ vss
+ stage3[92]
+ stage4[183]
+ inv
Xs5_183
+ vdd
+ vss
+ stage4[183]
+ stage5[183]
+ inv
Xff_183
+ b
+ stage5[183]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[183]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_184_0
+ vdd
+ vss
+ stage3[92]
+ stage4[184]
+ inv
Xs4_184_1
+ vdd
+ vss
+ stage3[92]
+ stage4[184]
+ inv
Xs5_184
+ vdd
+ vss
+ stage4[184]
+ stage5[184]
+ inv
Xff_184
+ b
+ stage5[184]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[184]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_185_0
+ vdd
+ vss
+ stage3[92]
+ stage4[185]
+ inv
Xs4_185_1
+ vdd
+ vss
+ stage3[93]
+ stage4[185]
+ inv
Xs5_185
+ vdd
+ vss
+ stage4[185]
+ stage5[185]
+ inv
Xff_185
+ b
+ stage5[185]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[185]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_186_0
+ vdd
+ vss
+ stage3[93]
+ stage4[186]
+ inv
Xs4_186_1
+ vdd
+ vss
+ stage3[93]
+ stage4[186]
+ inv
Xs5_186
+ vdd
+ vss
+ stage4[186]
+ stage5[186]
+ inv
Xff_186
+ b
+ stage5[186]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[186]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_187_0
+ vdd
+ vss
+ stage3[93]
+ stage4[187]
+ inv
Xs4_187_1
+ vdd
+ vss
+ stage3[94]
+ stage4[187]
+ inv
Xs5_187
+ vdd
+ vss
+ stage4[187]
+ stage5[187]
+ inv
Xff_187
+ b
+ stage5[187]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[187]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_188_0
+ vdd
+ vss
+ stage3[94]
+ stage4[188]
+ inv
Xs4_188_1
+ vdd
+ vss
+ stage3[94]
+ stage4[188]
+ inv
Xs5_188
+ vdd
+ vss
+ stage4[188]
+ stage5[188]
+ inv
Xff_188
+ b
+ stage5[188]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[188]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_189_0
+ vdd
+ vss
+ stage3[94]
+ stage4[189]
+ inv
Xs4_189_1
+ vdd
+ vss
+ stage3[95]
+ stage4[189]
+ inv
Xs5_189
+ vdd
+ vss
+ stage4[189]
+ stage5[189]
+ inv
Xff_189
+ b
+ stage5[189]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[189]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_190_0
+ vdd
+ vss
+ stage3[95]
+ stage4[190]
+ inv
Xs4_190_1
+ vdd
+ vss
+ stage3[95]
+ stage4[190]
+ inv
Xs5_190
+ vdd
+ vss
+ stage4[190]
+ stage5[190]
+ inv
Xff_190
+ b
+ stage5[190]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[190]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_191_0
+ vdd
+ vss
+ stage3[95]
+ stage4[191]
+ inv
Xs4_191_1
+ vdd
+ vss
+ stage3[96]
+ stage4[191]
+ inv
Xs5_191
+ vdd
+ vss
+ stage4[191]
+ stage5[191]
+ inv
Xff_191
+ b
+ stage5[191]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[191]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_192_0
+ vdd
+ vss
+ stage3[96]
+ stage4[192]
+ inv
Xs4_192_1
+ vdd
+ vss
+ stage3[96]
+ stage4[192]
+ inv
Xs5_192
+ vdd
+ vss
+ stage4[192]
+ stage5[192]
+ inv
Xff_192
+ b
+ stage5[192]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[192]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_193_0
+ vdd
+ vss
+ stage3[96]
+ stage4[193]
+ inv
Xs4_193_1
+ vdd
+ vss
+ stage3[97]
+ stage4[193]
+ inv
Xs5_193
+ vdd
+ vss
+ stage4[193]
+ stage5[193]
+ inv
Xff_193
+ b
+ stage5[193]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[193]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_194_0
+ vdd
+ vss
+ stage3[97]
+ stage4[194]
+ inv
Xs4_194_1
+ vdd
+ vss
+ stage3[97]
+ stage4[194]
+ inv
Xs5_194
+ vdd
+ vss
+ stage4[194]
+ stage5[194]
+ inv
Xff_194
+ b
+ stage5[194]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[194]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_195_0
+ vdd
+ vss
+ stage3[97]
+ stage4[195]
+ inv
Xs4_195_1
+ vdd
+ vss
+ stage3[98]
+ stage4[195]
+ inv
Xs5_195
+ vdd
+ vss
+ stage4[195]
+ stage5[195]
+ inv
Xff_195
+ b
+ stage5[195]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[195]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_196_0
+ vdd
+ vss
+ stage3[98]
+ stage4[196]
+ inv
Xs4_196_1
+ vdd
+ vss
+ stage3[98]
+ stage4[196]
+ inv
Xs5_196
+ vdd
+ vss
+ stage4[196]
+ stage5[196]
+ inv
Xff_196
+ b
+ stage5[196]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[196]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_197_0
+ vdd
+ vss
+ stage3[98]
+ stage4[197]
+ inv
Xs4_197_1
+ vdd
+ vss
+ stage3[99]
+ stage4[197]
+ inv
Xs5_197
+ vdd
+ vss
+ stage4[197]
+ stage5[197]
+ inv
Xff_197
+ b
+ stage5[197]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[197]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_198_0
+ vdd
+ vss
+ stage3[99]
+ stage4[198]
+ inv
Xs4_198_1
+ vdd
+ vss
+ stage3[99]
+ stage4[198]
+ inv
Xs5_198
+ vdd
+ vss
+ stage4[198]
+ stage5[198]
+ inv
Xff_198
+ b
+ stage5[198]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[198]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_199_0
+ vdd
+ vss
+ stage3[99]
+ stage4[199]
+ inv
Xs4_199_1
+ vdd
+ vss
+ stage3[100]
+ stage4[199]
+ inv
Xs5_199
+ vdd
+ vss
+ stage4[199]
+ stage5[199]
+ inv
Xff_199
+ b
+ stage5[199]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[199]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_200_0
+ vdd
+ vss
+ stage3[100]
+ stage4[200]
+ inv
Xs4_200_1
+ vdd
+ vss
+ stage3[100]
+ stage4[200]
+ inv
Xs5_200
+ vdd
+ vss
+ stage4[200]
+ stage5[200]
+ inv
Xff_200
+ b
+ stage5[200]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[200]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_201_0
+ vdd
+ vss
+ stage3[100]
+ stage4[201]
+ inv
Xs4_201_1
+ vdd
+ vss
+ stage3[101]
+ stage4[201]
+ inv
Xs5_201
+ vdd
+ vss
+ stage4[201]
+ stage5[201]
+ inv
Xff_201
+ b
+ stage5[201]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[201]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_202_0
+ vdd
+ vss
+ stage3[101]
+ stage4[202]
+ inv
Xs4_202_1
+ vdd
+ vss
+ stage3[101]
+ stage4[202]
+ inv
Xs5_202
+ vdd
+ vss
+ stage4[202]
+ stage5[202]
+ inv
Xff_202
+ b
+ stage5[202]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[202]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_203_0
+ vdd
+ vss
+ stage3[101]
+ stage4[203]
+ inv
Xs4_203_1
+ vdd
+ vss
+ stage3[102]
+ stage4[203]
+ inv
Xs5_203
+ vdd
+ vss
+ stage4[203]
+ stage5[203]
+ inv
Xff_203
+ b
+ stage5[203]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[203]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_204_0
+ vdd
+ vss
+ stage3[102]
+ stage4[204]
+ inv
Xs4_204_1
+ vdd
+ vss
+ stage3[102]
+ stage4[204]
+ inv
Xs5_204
+ vdd
+ vss
+ stage4[204]
+ stage5[204]
+ inv
Xff_204
+ b
+ stage5[204]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[204]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_205_0
+ vdd
+ vss
+ stage3[102]
+ stage4[205]
+ inv
Xs4_205_1
+ vdd
+ vss
+ stage3[103]
+ stage4[205]
+ inv
Xs5_205
+ vdd
+ vss
+ stage4[205]
+ stage5[205]
+ inv
Xff_205
+ b
+ stage5[205]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[205]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_206_0
+ vdd
+ vss
+ stage3[103]
+ stage4[206]
+ inv
Xs4_206_1
+ vdd
+ vss
+ stage3[103]
+ stage4[206]
+ inv
Xs5_206
+ vdd
+ vss
+ stage4[206]
+ stage5[206]
+ inv
Xff_206
+ b
+ stage5[206]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[206]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_207_0
+ vdd
+ vss
+ stage3[103]
+ stage4[207]
+ inv
Xs4_207_1
+ vdd
+ vss
+ stage3[104]
+ stage4[207]
+ inv
Xs5_207
+ vdd
+ vss
+ stage4[207]
+ stage5[207]
+ inv
Xff_207
+ b
+ stage5[207]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[207]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_208_0
+ vdd
+ vss
+ stage3[104]
+ stage4[208]
+ inv
Xs4_208_1
+ vdd
+ vss
+ stage3[104]
+ stage4[208]
+ inv
Xs5_208
+ vdd
+ vss
+ stage4[208]
+ stage5[208]
+ inv
Xff_208
+ b
+ stage5[208]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[208]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_209_0
+ vdd
+ vss
+ stage3[104]
+ stage4[209]
+ inv
Xs4_209_1
+ vdd
+ vss
+ stage3[105]
+ stage4[209]
+ inv
Xs5_209
+ vdd
+ vss
+ stage4[209]
+ stage5[209]
+ inv
Xff_209
+ b
+ stage5[209]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[209]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_210_0
+ vdd
+ vss
+ stage3[105]
+ stage4[210]
+ inv
Xs4_210_1
+ vdd
+ vss
+ stage3[105]
+ stage4[210]
+ inv
Xs5_210
+ vdd
+ vss
+ stage4[210]
+ stage5[210]
+ inv
Xff_210
+ b
+ stage5[210]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[210]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_211_0
+ vdd
+ vss
+ stage3[105]
+ stage4[211]
+ inv
Xs4_211_1
+ vdd
+ vss
+ stage3[106]
+ stage4[211]
+ inv
Xs5_211
+ vdd
+ vss
+ stage4[211]
+ stage5[211]
+ inv
Xff_211
+ b
+ stage5[211]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[211]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_212_0
+ vdd
+ vss
+ stage3[106]
+ stage4[212]
+ inv
Xs4_212_1
+ vdd
+ vss
+ stage3[106]
+ stage4[212]
+ inv
Xs5_212
+ vdd
+ vss
+ stage4[212]
+ stage5[212]
+ inv
Xff_212
+ b
+ stage5[212]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[212]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_213_0
+ vdd
+ vss
+ stage3[106]
+ stage4[213]
+ inv
Xs4_213_1
+ vdd
+ vss
+ stage3[107]
+ stage4[213]
+ inv
Xs5_213
+ vdd
+ vss
+ stage4[213]
+ stage5[213]
+ inv
Xff_213
+ b
+ stage5[213]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[213]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_214_0
+ vdd
+ vss
+ stage3[107]
+ stage4[214]
+ inv
Xs4_214_1
+ vdd
+ vss
+ stage3[107]
+ stage4[214]
+ inv
Xs5_214
+ vdd
+ vss
+ stage4[214]
+ stage5[214]
+ inv
Xff_214
+ b
+ stage5[214]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[214]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_215_0
+ vdd
+ vss
+ stage3[107]
+ stage4[215]
+ inv
Xs4_215_1
+ vdd
+ vss
+ stage3[108]
+ stage4[215]
+ inv
Xs5_215
+ vdd
+ vss
+ stage4[215]
+ stage5[215]
+ inv
Xff_215
+ b
+ stage5[215]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[215]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_216_0
+ vdd
+ vss
+ stage3[108]
+ stage4[216]
+ inv
Xs4_216_1
+ vdd
+ vss
+ stage3[108]
+ stage4[216]
+ inv
Xs5_216
+ vdd
+ vss
+ stage4[216]
+ stage5[216]
+ inv
Xff_216
+ b
+ stage5[216]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[216]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_217_0
+ vdd
+ vss
+ stage3[108]
+ stage4[217]
+ inv
Xs4_217_1
+ vdd
+ vss
+ stage3[109]
+ stage4[217]
+ inv
Xs5_217
+ vdd
+ vss
+ stage4[217]
+ stage5[217]
+ inv
Xff_217
+ b
+ stage5[217]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[217]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_218_0
+ vdd
+ vss
+ stage3[109]
+ stage4[218]
+ inv
Xs4_218_1
+ vdd
+ vss
+ stage3[109]
+ stage4[218]
+ inv
Xs5_218
+ vdd
+ vss
+ stage4[218]
+ stage5[218]
+ inv
Xff_218
+ b
+ stage5[218]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[218]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_219_0
+ vdd
+ vss
+ stage3[109]
+ stage4[219]
+ inv
Xs4_219_1
+ vdd
+ vss
+ stage3[110]
+ stage4[219]
+ inv
Xs5_219
+ vdd
+ vss
+ stage4[219]
+ stage5[219]
+ inv
Xff_219
+ b
+ stage5[219]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[219]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_220_0
+ vdd
+ vss
+ stage3[110]
+ stage4[220]
+ inv
Xs4_220_1
+ vdd
+ vss
+ stage3[110]
+ stage4[220]
+ inv
Xs5_220
+ vdd
+ vss
+ stage4[220]
+ stage5[220]
+ inv
Xff_220
+ b
+ stage5[220]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[220]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_221_0
+ vdd
+ vss
+ stage3[110]
+ stage4[221]
+ inv
Xs4_221_1
+ vdd
+ vss
+ stage3[111]
+ stage4[221]
+ inv
Xs5_221
+ vdd
+ vss
+ stage4[221]
+ stage5[221]
+ inv
Xff_221
+ b
+ stage5[221]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[221]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_222_0
+ vdd
+ vss
+ stage3[111]
+ stage4[222]
+ inv
Xs4_222_1
+ vdd
+ vss
+ stage3[111]
+ stage4[222]
+ inv
Xs5_222
+ vdd
+ vss
+ stage4[222]
+ stage5[222]
+ inv
Xff_222
+ b
+ stage5[222]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[222]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_223_0
+ vdd
+ vss
+ stage3[111]
+ stage4[223]
+ inv
Xs4_223_1
+ vdd
+ vss
+ stage3[112]
+ stage4[223]
+ inv
Xs5_223
+ vdd
+ vss
+ stage4[223]
+ stage5[223]
+ inv
Xff_223
+ b
+ stage5[223]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[223]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_224_0
+ vdd
+ vss
+ stage3[112]
+ stage4[224]
+ inv
Xs4_224_1
+ vdd
+ vss
+ stage3[112]
+ stage4[224]
+ inv
Xs5_224
+ vdd
+ vss
+ stage4[224]
+ stage5[224]
+ inv
Xff_224
+ b
+ stage5[224]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[224]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_225_0
+ vdd
+ vss
+ stage3[112]
+ stage4[225]
+ inv
Xs4_225_1
+ vdd
+ vss
+ stage3[113]
+ stage4[225]
+ inv
Xs5_225
+ vdd
+ vss
+ stage4[225]
+ stage5[225]
+ inv
Xff_225
+ b
+ stage5[225]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[225]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_226_0
+ vdd
+ vss
+ stage3[113]
+ stage4[226]
+ inv
Xs4_226_1
+ vdd
+ vss
+ stage3[113]
+ stage4[226]
+ inv
Xs5_226
+ vdd
+ vss
+ stage4[226]
+ stage5[226]
+ inv
Xff_226
+ b
+ stage5[226]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[226]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_227_0
+ vdd
+ vss
+ stage3[113]
+ stage4[227]
+ inv
Xs4_227_1
+ vdd
+ vss
+ stage3[114]
+ stage4[227]
+ inv
Xs5_227
+ vdd
+ vss
+ stage4[227]
+ stage5[227]
+ inv
Xff_227
+ b
+ stage5[227]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[227]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_228_0
+ vdd
+ vss
+ stage3[114]
+ stage4[228]
+ inv
Xs4_228_1
+ vdd
+ vss
+ stage3[114]
+ stage4[228]
+ inv
Xs5_228
+ vdd
+ vss
+ stage4[228]
+ stage5[228]
+ inv
Xff_228
+ b
+ stage5[228]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[228]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_229_0
+ vdd
+ vss
+ stage3[114]
+ stage4[229]
+ inv
Xs4_229_1
+ vdd
+ vss
+ stage3[115]
+ stage4[229]
+ inv
Xs5_229
+ vdd
+ vss
+ stage4[229]
+ stage5[229]
+ inv
Xff_229
+ b
+ stage5[229]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[229]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_230_0
+ vdd
+ vss
+ stage3[115]
+ stage4[230]
+ inv
Xs4_230_1
+ vdd
+ vss
+ stage3[115]
+ stage4[230]
+ inv
Xs5_230
+ vdd
+ vss
+ stage4[230]
+ stage5[230]
+ inv
Xff_230
+ b
+ stage5[230]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[230]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_231_0
+ vdd
+ vss
+ stage3[115]
+ stage4[231]
+ inv
Xs4_231_1
+ vdd
+ vss
+ stage3[116]
+ stage4[231]
+ inv
Xs5_231
+ vdd
+ vss
+ stage4[231]
+ stage5[231]
+ inv
Xff_231
+ b
+ stage5[231]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[231]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_232_0
+ vdd
+ vss
+ stage3[116]
+ stage4[232]
+ inv
Xs4_232_1
+ vdd
+ vss
+ stage3[116]
+ stage4[232]
+ inv
Xs5_232
+ vdd
+ vss
+ stage4[232]
+ stage5[232]
+ inv
Xff_232
+ b
+ stage5[232]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[232]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_233_0
+ vdd
+ vss
+ stage3[116]
+ stage4[233]
+ inv
Xs4_233_1
+ vdd
+ vss
+ stage3[117]
+ stage4[233]
+ inv
Xs5_233
+ vdd
+ vss
+ stage4[233]
+ stage5[233]
+ inv
Xff_233
+ b
+ stage5[233]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[233]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_234_0
+ vdd
+ vss
+ stage3[117]
+ stage4[234]
+ inv
Xs4_234_1
+ vdd
+ vss
+ stage3[117]
+ stage4[234]
+ inv
Xs5_234
+ vdd
+ vss
+ stage4[234]
+ stage5[234]
+ inv
Xff_234
+ b
+ stage5[234]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[234]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_235_0
+ vdd
+ vss
+ stage3[117]
+ stage4[235]
+ inv
Xs4_235_1
+ vdd
+ vss
+ stage3[118]
+ stage4[235]
+ inv
Xs5_235
+ vdd
+ vss
+ stage4[235]
+ stage5[235]
+ inv
Xff_235
+ b
+ stage5[235]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[235]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_236_0
+ vdd
+ vss
+ stage3[118]
+ stage4[236]
+ inv
Xs4_236_1
+ vdd
+ vss
+ stage3[118]
+ stage4[236]
+ inv
Xs5_236
+ vdd
+ vss
+ stage4[236]
+ stage5[236]
+ inv
Xff_236
+ b
+ stage5[236]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[236]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_237_0
+ vdd
+ vss
+ stage3[118]
+ stage4[237]
+ inv
Xs4_237_1
+ vdd
+ vss
+ stage3[119]
+ stage4[237]
+ inv
Xs5_237
+ vdd
+ vss
+ stage4[237]
+ stage5[237]
+ inv
Xff_237
+ b
+ stage5[237]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[237]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_238_0
+ vdd
+ vss
+ stage3[119]
+ stage4[238]
+ inv
Xs4_238_1
+ vdd
+ vss
+ stage3[119]
+ stage4[238]
+ inv
Xs5_238
+ vdd
+ vss
+ stage4[238]
+ stage5[238]
+ inv
Xff_238
+ b
+ stage5[238]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[238]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_239_0
+ vdd
+ vss
+ stage3[119]
+ stage4[239]
+ inv
Xs4_239_1
+ vdd
+ vss
+ stage3[120]
+ stage4[239]
+ inv
Xs5_239
+ vdd
+ vss
+ stage4[239]
+ stage5[239]
+ inv
Xff_239
+ b
+ stage5[239]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[239]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_240_0
+ vdd
+ vss
+ stage3[120]
+ stage4[240]
+ inv
Xs4_240_1
+ vdd
+ vss
+ stage3[120]
+ stage4[240]
+ inv
Xs5_240
+ vdd
+ vss
+ stage4[240]
+ stage5[240]
+ inv
Xff_240
+ b
+ stage5[240]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[240]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_241_0
+ vdd
+ vss
+ stage3[120]
+ stage4[241]
+ inv
Xs4_241_1
+ vdd
+ vss
+ stage3[121]
+ stage4[241]
+ inv
Xs5_241
+ vdd
+ vss
+ stage4[241]
+ stage5[241]
+ inv
Xff_241
+ b
+ stage5[241]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[241]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_242_0
+ vdd
+ vss
+ stage3[121]
+ stage4[242]
+ inv
Xs4_242_1
+ vdd
+ vss
+ stage3[121]
+ stage4[242]
+ inv
Xs5_242
+ vdd
+ vss
+ stage4[242]
+ stage5[242]
+ inv
Xff_242
+ b
+ stage5[242]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[242]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_243_0
+ vdd
+ vss
+ stage3[121]
+ stage4[243]
+ inv
Xs4_243_1
+ vdd
+ vss
+ stage3[122]
+ stage4[243]
+ inv
Xs5_243
+ vdd
+ vss
+ stage4[243]
+ stage5[243]
+ inv
Xff_243
+ b
+ stage5[243]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[243]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_244_0
+ vdd
+ vss
+ stage3[122]
+ stage4[244]
+ inv
Xs4_244_1
+ vdd
+ vss
+ stage3[122]
+ stage4[244]
+ inv
Xs5_244
+ vdd
+ vss
+ stage4[244]
+ stage5[244]
+ inv
Xff_244
+ b
+ stage5[244]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[244]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_245_0
+ vdd
+ vss
+ stage3[122]
+ stage4[245]
+ inv
Xs4_245_1
+ vdd
+ vss
+ stage3[123]
+ stage4[245]
+ inv
Xs5_245
+ vdd
+ vss
+ stage4[245]
+ stage5[245]
+ inv
Xff_245
+ b
+ stage5[245]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[245]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_246_0
+ vdd
+ vss
+ stage3[123]
+ stage4[246]
+ inv
Xs4_246_1
+ vdd
+ vss
+ stage3[123]
+ stage4[246]
+ inv
Xs5_246
+ vdd
+ vss
+ stage4[246]
+ stage5[246]
+ inv
Xff_246
+ b
+ stage5[246]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[246]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_247_0
+ vdd
+ vss
+ stage3[123]
+ stage4[247]
+ inv
Xs4_247_1
+ vdd
+ vss
+ stage3[124]
+ stage4[247]
+ inv
Xs5_247
+ vdd
+ vss
+ stage4[247]
+ stage5[247]
+ inv
Xff_247
+ b
+ stage5[247]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[247]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_248_0
+ vdd
+ vss
+ stage3[124]
+ stage4[248]
+ inv
Xs4_248_1
+ vdd
+ vss
+ stage3[124]
+ stage4[248]
+ inv
Xs5_248
+ vdd
+ vss
+ stage4[248]
+ stage5[248]
+ inv
Xff_248
+ b
+ stage5[248]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[248]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_249_0
+ vdd
+ vss
+ stage3[124]
+ stage4[249]
+ inv
Xs4_249_1
+ vdd
+ vss
+ stage3[125]
+ stage4[249]
+ inv
Xs5_249
+ vdd
+ vss
+ stage4[249]
+ stage5[249]
+ inv
Xff_249
+ b
+ stage5[249]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[249]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_250_0
+ vdd
+ vss
+ stage3[125]
+ stage4[250]
+ inv
Xs4_250_1
+ vdd
+ vss
+ stage3[125]
+ stage4[250]
+ inv
Xs5_250
+ vdd
+ vss
+ stage4[250]
+ stage5[250]
+ inv
Xff_250
+ b
+ stage5[250]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[250]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
Xs4_251_0
+ vdd
+ vss
+ stage3[125]
+ stage4[251]
+ inv
Xs4_251_1
+ vdd
+ vss
+ stage3[126]
+ stage4[251]
+ inv
Xs5_251
+ vdd
+ vss
+ stage4[251]
+ stage5[251]
+ inv
Xff_251
+ b
+ stage5[251]
+ reset_b
+ vss
+ vss
+ vdd
+ vdd
+ dout[251]
+ sky130_fd_sc_hd__dfrtp_2_wrapper
.ends tdc_64

.subckt inv
+ vdd
+ vss
+ din
+ din_b

XMP0
+ din_b
+ din
+ vdd
+ vdd
+ mos_w1800_l150_m1_nf1_id1
XMN0
+ din_b
+ din
+ vss
+ vss
+ mos_w1000_l150_m1_nf1_id0
.ends inv

.subckt sky130_fd_sc_hd__dfrtp_2_wrapper
+ CLK
+ D
+ RESET_B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Q

X0
+ CLK
+ D
+ RESET_B
+ VGND
+ VNB
+ VPB
+ VPWR
+ Q
+ sky130_fd_sc_hd__dfrtp_2
.ends sky130_fd_sc_hd__dfrtp_2_wrapper

.subckt mos_w1800_l150_m1_nf1_id1
+ d
+ g
+ s
+ b

M0 d g s b pshort w=1.800 l=0.150 nf=1 mult=1
.ends mos_w1800_l150_m1_nf1_id1

.subckt mos_w1000_l150_m1_nf1_id0
+ d
+ g
+ s
+ b

M0 d g s b nshort w=1.000 l=0.150 nf=1 mult=1
.ends mos_w1000_l150_m1_nf1_id0

.include "/bwrcq/C/rahulkumar/sky130/skywater-pdk/libraries/sky130_fd_sc_hd/latest/cells/dfrtp/sky130_fd_sc_hd__dfrtp_2.spice"
